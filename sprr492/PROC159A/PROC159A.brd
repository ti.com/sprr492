# Allegro board PROC159A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
OSPI_CLK: length 25.1
  TOP w0.147: v1(35.68,39.74) 36,40.06 R110.1 34.14,40.37 U19.B2
  L03_SIG1 w0.091: v1(35.68,39.74) 35.68,36.38 36.17,35.89 36.85,35.89 36.93,35.97 36.93,36.32 37.01,36.4 37.13,36.4 37.21,36.32 37.21,35.97 37.29,35.89 37.4,35.89 37.48,35.97 37.48,36.32 37.56,36.4 37.68,36.4 37.76,36.32 37.76,35.97 37.84,35.89 39.05,35.89 39.14,35.98 39.14,36.78 39.79,37.43 39.79,37.85 39.79,37.85 39.79,41.64 39.79,41.64 39.79,42.43 39.79,42.43 39.79,43.94 41.35,45.5 41.46,45.5 v1(41.73,45.76)
  BOTTOM w0.147: U80.42 v1(41.73,45.76)
OSPI_CS0: length 19.2
  TOP w0.147: v1(36.31,41.01) 36.1,41.23 R109.2 34.37,41.73 34.02,42.08 33.43,42.08 U19.C2 ; v1(46.1,37.38) TP45.1 48.05,36.83 48.92,36.83 R98.1
  L08_SIG2 w0.091: v1(36.31,41.01) 36.34,41.01 37.55,39.8 38.46,39.8 39.69,38.58 42.17,38.58 43.37,37.38 v1(46.1,37.38)
OSPI_DQ0: length 21.6
  TOP w0.147: R451.2 v1(32.6,49.39)
  L03_SIG1 w0.091: v1(40.73,45.76) 41.22,46.25 41.22,48 39.44,49.79 35.07,49.79 34.99,49.71 34.99,49.6 35.07,49.52 38.16,49.52 38.24,49.44 38.24,49.32 38.16,49.24 34.8,49.24 34.25,49.79 33,49.79 v1(32.6,49.39)
  BOTTOM w0.147: v1(32.6,49.39) 32.59,49.38 R100.1 ; U80.40 v1(40.73,45.76)
OSPI_DQ1: length 22.5
  TOP w0.147: v1(37.08,44.65) R452.2
  L03_SIG1 w0.091: v1(38.5,45.98) 38.5,45.49 38.25,45.23 36.49,45.23 35.87,45.86 35.87,48.35 35.95,48.43 36.06,48.43 36.14,48.35 36.14,46.07 36.31,45.9 36.43,45.9 36.51,45.98 36.51,48.53 36.36,48.68 35.68,48.68 35.53,48.53 35.53,45.59 36.47,44.65 v1(37.08,44.65)
  BOTTOM w0.147: v1(37.08,44.65) 37.08,43.68 37.06,43.66 R101.1 ; U80.37 38.71,43.82 38.5,44.03 v1(38.5,45.98)
OSPI_DQ2: length 23.4
  TOP w0.147: R453.2 v1(26.31,42.3) R102.2
  L03_SIG1 w0.091: v1(26.31,42.3) 28.09,44.09 30.58,44.09 33.13,41.54 36.72,41.54 36.8,41.62 36.8,41.74 36.72,41.82 33.98,41.82 33.9,41.9 33.9,42.01 33.98,42.09 37.43,42.09 v1(38.16,42.82)
  BOTTOM w0.147: U80.35 v1(38.16,42.82)
OSPI_DQ3: length 23
  TOP w0.147: R103.1 v1(26.31,44.84) R454.2
  L03_SIG1 w0.091: v1(38.16,41.82) 38.69,42.35 38.69,43.34 38.69,43.86 38.5,44.05 37.99,44.05 37.5,43.55 36.14,43.55 35.2,44.49 32.08,44.49 31.95,44.37 31.95,44.24 32.04,44.14 33.58,44.14 33.69,44.04 33.69,43.86 33.59,43.76 31.51,43.76 30.78,44.49 26.66,44.49 v1(26.31,44.84)
  BOTTOM w0.147: U80.33 v1(38.16,41.82)
OSPI_DQ4: length 24.7
  TOP w0.147: R455.2 v1(26.31,43.57) R104.1
  L03_SIG1 w0.091: v1(26.31,43.57) 25.88,43.14 25.88,42.12 26.13,41.87 27.04,41.87 28.86,43.69 30.45,43.69 33.57,40.57 35.59,40.57 35.67,40.65 35.67,40.76 35.58,40.85 33.68,40.85 33.59,40.94 33.59,41.05 33.67,41.13 35.7,41.13 35.88,40.95 35.88,40.79 36.26,40.41 36.82,40.41 37.91,39.32 v1(38.29,39.32)
  BOTTOM w0.147: U80.28 v1(38.29,39.32)
OSPI_DQ5: length 22.5
  TOP w0.147: R456.2 v1(30.48,48.63)
  L03_SIG1 w0.091: v1(30.48,48.63) 30.48,47.75 30.56,47.67 30.85,47.67 30.93,47.59 30.93,47.48 30.85,47.4 30.56,47.4 30.48,47.32 30.48,47.2 30.56,47.12 30.85,47.12 30.93,47.04 30.93,46.93 30.85,46.85 30.56,46.85 30.48,46.77 30.48,45.84 31.49,44.82 35.43,44.82 36.38,43.87 37.43,43.87 37.87,44.32 38.61,44.32 38.96,43.97 38.96,43.12 38.96,39 v1(38.29,38.32)
  BOTTOM w0.147: U80.26 v1(38.29,38.32) ; v1(30.48,48.63) 30.63,48.63 30.65,48.61 R105.1
OSPI_DQ6: length 22.5
  TOP w0.147: v1(33.93,49.36) 33.85,49.28 R457.2
  L03_SIG1 w0.091: v1(33.93,49.36) 33.38,48.81 33.38,47.06 33.5,46.95 33.68,46.95 33.81,47.08 33.81,48.25 33.93,48.37 34.1,48.37 34.23,48.25 34.23,46.49 36.49,44.22 37.39,44.22 37.6,44.43 37.76,44.59 38.5,44.59 38.73,44.59 39.24,44.08 39.24,43.01 39.24,38.27 v1(38.29,37.32)
  BOTTOM w0.147: v1(33.93,49.36) 33.93,49.31 33.99,49.25 R106.1 ; U80.24 v1(38.29,37.32)
OSPI_DQ7: length 23.3
  TOP w0.147: R458.2 v1(37.08,46.22)
  L03_SIG1 w0.091: v1(38.29,36.32) 39.51,37.55 39.51,44.44 39.79,44.72 39.79,45.52 38.73,46.59 38.2,46.59 38.11,46.68 38.11,48.45 38.03,48.53 37.91,48.53 37.83,48.45 37.83,46.67 37.75,46.59 37.6,46.59 37.39,46.8 37.39,48.4 37.28,48.5 37.15,48.5 37.06,48.41 37.06,46.6 37.08,46.59 v1(37.08,46.22)
  BOTTOM w0.147: U80.22 v1(38.29,36.32) ; R107.1 37.06,46.2 v1(37.08,46.22)
OSPI_DQS_SOC: length 18.4
  L03_SIG1 w0.091: v1(30.26,43.16) 29.85,42.75 29.85,39.25 34.23,34.88 v1(40.73,34.88)
  BOTTOM w0.147: R112.2 v1(30.26,43.16) ; U80.20 v1(40.73,34.88)
OSPI_ERR#: length 43.4
  TOP w0.147: v1(48.52,46.32) 48.56,46.27 R3865.2 ; U19.A5 R108.1 27.49,40.15 27.75,39.89 v1(28.01,39.89)
  L03_SIG1 w0.091: v1(48.52,46.32) 48.12,46.72 47.47,46.72 47.14,46.39 47.14,45.06 48.46,43.74 48.82,43.74 49.36,43.19 49.36,38.2 49.01,37.85 49.01,34.94 47.94,33.87 32.66,33.87 29.5,37.03 29.5,38.4 v1(28.01,39.89)
OSPI_LBCLK: length 22.2
  L03_SIG1 w0.091: v1(41.73,34.88) 41.3,34.45 33.99,34.45 28.82,39.62 28.82,42.27 v1(29.21,42.66)
  BOTTOM w0.147: v1(29.21,42.66) 29.21,43.47 29.91,44.18 R114.2 ; U80.18 v1(41.73,34.88)
OSPI_RSTN: length 9.2
  TOP w0.147: v1(30.98,38.72) 30.98,39.18 30.85,39.31 U19.A4
  BOTTOM w0.147: U21.4 R121.1 35.68,38.2 35.16,38.72 v1(30.98,38.72)
OSPI_RSTN_R: length 3.3
  TOP w0.147: R3879.2 35.06,35.3 R3878.1 36.38,34.94 35.85,34.41 35.85,33.62 Q21.3
PMIC_COMP1_IN+: length 45.9
  TOP w0.147: v1(110.49,5.58) 110.92,5.14 110.92,4.36 110.44,3.88 J15.175 ; v1(109.12,34.27) 108.79,34.59 108.79,35.08 107.69,36.18 U7.21
  L03_SIG1 w0.091: v1(109.12,34.27) 108.75,33.9 108.75,28.47 107.65,27.37 105.49,27.37 104.3,26.18 104.3,23.15 105.66,21.8 105.66,16.84 104.31,15.5 104.31,10.73 106.01,9.04 110.11,9.04 111.19,7.96 111.19,6.28 v1(110.49,5.58)
PMIC_COMP1_IN-: length 48.6
  TOP w0.147: v1(110.49,6.59) 111.24,5.84 J15.177 ; v1(110.89,34.34) 110.57,34.66 110.57,35.42 109.19,36.79 U7.24
  L03_SIG1 w0.091: v1(110.89,34.34) 110.41,34.82 109,34.82 108.51,34.33 108.51,28.71 107.53,27.73 105.45,27.73 103.86,26.14 103.86,23.07 105.47,21.46 105.47,18.31 104.02,16.86 104.02,10.66 106,8.68 110.09,8.68 110.93,7.84 110.93,7.04 v1(110.49,6.59)
PMIC_COMP2_IN+: length 56.7
  TOP w0.147: U7.28 107.69,46.57 v1(108.23,47.1) ; J15.171 v1(108.84,4.56)
  L03_SIG1 w0.091: v1(108.23,47.1) 105.76,44.64 104.3,44.64 102.93,43.26 102.93,38.71 101.14,36.92 101.14,27.38 101.59,26.94 101.59,19.79 102.32,19.06 102.32,9.41 104.73,7 104.73,4.86 105.46,4.13 108.41,4.13 v1(108.84,4.56)
PMIC_COMP2_IN-: length 55.7
  TOP w0.147: U7.25 109.19,45.99 v1(109.15,46.04) ; v1(110.49,7.61) 109.98,7.1 109.98,6.03 109.64,5.69 J15.173
  L03_SIG1 w0.091: v1(110.49,7.61) 109.74,8.36 105.97,8.36 103.75,10.58 103.75,17.27 104.5,18.02 104.5,21.88 103.53,22.85 103.53,26.74 101.81,28.46 101.81,34.08 102.86,35.13 102.86,36.59 104.51,38.24 106.4,38.24 106.99,38.83 106.99,43.89 v1(109.15,46.04)
PMIC_DIAG_OUT: length 78.9
  TOP w0.147: U7.32 v1(105.69,46.09) ; U1.V4 v1(55.38,32.83)
  L08_SIG2 w0.091: v1(105.69,46.09) 105.69,43.96 105.98,43.67 105.98,37.1 106.17,36.91 106.17,35.07 105.2,34.1 105.2,33.26 102.81,30.87 102.28,30.87 100.32,28.92 v1(100.32,25.79)
  BOTTOM w0.147: v1(100.32,25.79) 99.73,25.19 98.88,25.19 98.29,25.79 95.11,25.79 94.66,25.34 88.91,25.34 87.34,23.76 68.61,23.76 66.93,25.44 66.93,27.57 65.7,28.79 55.49,28.79 54.98,29.31 54.98,31.94 55.38,32.35 v1(55.38,32.83)
PMIC_EN_OUT: length 26.1
  TOP w0.147: U7.17 105.69,36.24 v1(105.74,36.19)
  L08_SIG2 w0.091: v1(97.62,48.91) 98.23,48.3 98.23,39.31 99.25,38.29 103.65,38.29 v1(105.74,36.19)
  BOTTOM w0.147: v1(97.62,48.91) 94.11,52.43 R51.1
PMIC_INTN: length 62.3
  TOP w0.147: v1(109.92,34.3) 109.3,34.93 109.3,35.3 108.19,36.4 U7.22 ; U1.R17 v1(66.58,35.23)
  L03_SIG1 w0.091: v1(106.44,26.69) 107.35,26.69 109.03,28.37 109.03,33.4 v1(109.92,34.3)
  BOTTOM w0.114: v1(66.58,35.23) 66.18,34.83 66.18,33.36
  BOTTOM w0.147: 66.18,33.36 66.18,29.93 67.49,28.63 67.49,26.99 68.22,26.25 87.75,26.25 88.18,26.69 v1(106.44,26.69)
PMIC_NRST: length 23.7
  TOP w0.147: v1(94.37,38.36) 93.54,37.53 84.93,37.53 84.05,36.65 R432.1 ; v1(104.26,35.93) 103.94,36.25 103.94,36.25 103.69,36.5 U7.13
  L08_SIG2 w0.091: v1(94.37,38.36) 97.05,38.36 97.87,37.55 102.64,37.55 v1(104.26,35.93)
PMIC_SAFE_OUT1: length 109.2
  TOP w0.147: J15.113 65.44,5.79 v1(66.24,6.59)
  L08_SIG2 w0.091: v1(66.24,6.59) 66.84,6.59 69.11,8.86 69.11,12.12 70.33,13.34 90.56,13.34 90.99,12.91 90.99,12.39 94.5,8.88 94.5,6.17 95.61,5.06 104.4,5.06 105.93,3.53 108.92,3.53 109.64,4.25 109.64,8.09 108.22,9.51 108.22,10.02 107.19,11.05 104.76,11.05 104.28,11.53 104.28,15.36 103.91,15.74 103.91,17.49 104.53,18.12 104.53,24.11 104.06,24.58 104.06,25.85 105.8,27.59 105.8,30.46 108.44,33.09 108.44,35.76 109.79,37.11 v1(109.79,45.36)
  BOTTOM w0.147: v1(109.79,45.36) 109.24,45.36 108.81,44.94 R32.1
PMIC_SAFE_OUT2: length 80.4
  TOP w0.147: v1(99.06,48.88) 98.51,48.88 97.67,48.04 97.24,48.04 95.78,46.58 95.78,41.67 94.07,39.96 R202.1 92.81,39.29 92.8,39.3 Q5.1 ; U7.27 v1(108.19,46.09)
  L03_SIG1 w0.091: v1(108.19,46.09) 106.36,44.26 104.94,44.26 103.89,43.21 103.89,38.8 101.44,36.35 101.44,28.37 103.06,26.75 103.06,21.1 102.8,20.84 102.8,18.97 102.56,18.73 102.56,9.46 105,7.03 105,6.44 105.36,6.08 109.05,6.08 109.76,5.37 109.76,5.11 v1(110.31,4.56)
  L08_SIG2 w0.091: v1(99.06,48.88) 101.53,48.88 102.25,48.16 106.77,48.16 107.62,47.31 107.62,46.66 v1(108.19,46.09)
  BOTTOM w0.147: J15.178 111.24,3.86 110.86,4.24 110.63,4.24 v1(110.31,4.56)
PMIC_SPI1_CLK: length 100.6
  TOP w0.147: v1(104.77,47.1) 105.19,46.68 U7.33 ; U8.2 60.61,12.97 62.35,14.71 64.51,14.71 65.18,14.04 88.94,14.04 89.86,13.12 89.86,12.46 90.2,12.11 92.52,12.11 95.12,9.51 102.5,9.51 102.87,9.88 105.13,9.88 105.48,9.53 106.09,9.53 v1(106.62,10.06)
  L08_SIG2 w0.091: v1(104.77,47.1) 105.26,47.59 106.12,47.59 106.69,47.02 106.69,45.63 108.01,44.31 108.01,38.61 107.67,38.27 107.67,34.99 107.3,34.62 107.3,33.32 103.59,29.61 103.59,26.86 100.56,23.83 100.56,15.5 103.77,12.29 103.77,11.44 104.62,10.59 106.09,10.59 v1(106.62,10.06)
  BOTTOM w0.147: R41.2 104.77,47.34 v1(104.77,47.1)
PMIC_SPI1_CS0: length 97
  TOP w0.147: U7.36 103.69,46.03 v1(103.75,46.08) ; v1(105.71,10.06) 105.39,10.38 102.8,10.38 102.3,9.87 95.32,9.87 91.79,13.4 90.11,13.4 89.16,14.36 65.51,14.36 64.64,15.23 62.1,15.23 61.26,16.06 U8.14
  L08_SIG2 w0.091: v1(103.75,46.08) 104.24,46.58 105.87,46.58 106.27,46.17 106.27,44.95 107,44.22 107,38.58 107.36,38.22 107.36,35.39 106.18,34.21 106.18,32.62 103.4,29.84 102.8,29.84 102.14,29.18 102.14,26.05 100.38,24.29 100.38,15.3 103.5,12.18 103.5,11.3 104.48,10.32 105.45,10.32 v1(105.71,10.06)
  BOTTOM w0.147: v1(103.75,46.08) 103.3,46.08 102.99,46.39 R39.2
PMIC_SPI1_D0: length 113.3
  TOP w0.147: v1(103.75,47.1) 104.22,46.64 104.22,45.94 104.19,45.92 U7.35 ; U8.5 62.56,13.53 63.27,14.24 64.38,14.24 64.89,13.73 88.69,13.73 89.5,12.92 89.5,12.28 90.02,11.75 92.37,11.75 94.99,9.13 102.71,9.13 103.1,9.52 104.88,9.52 105.29,9.12 106.6,9.12 v1(107.54,10.06) ; R40.2 109.11,54.22 109.08,54.19 TP17.1 v1(107.72,54.19)
  L03_SIG1 w0.091: v1(107.72,54.19) 107.72,52.31 104.52,49.1 104.52,47.87 v1(103.75,47.1)
  L08_SIG2 w0.091: v1(103.75,47.1) 104.52,47.87 106.37,47.87 107.07,47.17 107.07,46.23 109.4,43.9 109.4,38.16 108.23,36.99 108.23,33.34 107.75,32.86 107.21,32.86 104.76,30.41 104.76,27.59 100.74,23.57 100.74,15.69 104.05,12.39 104.05,11.42 104.63,10.83 106.76,10.83 v1(107.54,10.06)
PMIC_SPI1_D1: length 81.8
  TOP w0.147: U8.11 63.21,19.31 63.37,19.47 v1(63.37,19.93)
  L08_SIG2 w0.091: v1(104.86,25.88) 106.16,27.19 106.16,30.18 108.69,32.71 108.69,34.87 110.91,37.09 110.91,51.11 109.35,52.67 v1(109.35,55.35)
  BOTTOM w0.147: v1(63.37,19.93) 64.38,20.94 65.55,20.94 68.04,23.43 87.86,23.43 88.81,24.38 94.78,24.38 95.72,25.32 98.03,25.32 98.59,24.76 100.14,24.76 101.26,25.88 v1(104.86,25.88) ; v1(109.35,55.35) R38.2 R142.2
PMIC_WKUP1: length 67.4
  TOP w0.147: v1(100.22,36.06) 100.19,36.08 U7.6
  L03_SIG1 w0.091: v1(66.24,7.61) 66.24,8.83 66.95,9.54 66.95,10.49 70.75,14.29 71.94,14.29 75.93,18.28 75.93,24.63 v1(74.81,25.76)
  L08_SIG2 w0.091: v1(99.31,25.79) 99.83,26.31 99.83,35.67 v1(100.22,36.06)
  BOTTOM w0.147: v1(74.81,25.76) 75.26,25.76 75.4,25.62 R34.2 76.09,24.91 76.76,24.24 86.95,24.24 88.94,26.23 98.86,26.23 v1(99.31,25.79) ; v1(66.24,7.61) 65.44,6.81 J15.114
PMIC_WKUP2: length 102.1
  TOP w0.147: J22.1 75.91,18.46 79.65,14.72 89.34,14.72 90.31,13.75 91.98,13.75 94.87,10.86 107.4,10.86 108.03,10.23 108.03,9.26 109.39,7.89 109.39,6.13 v1(108.84,5.58) ; v1(98.67,47.87) 99.04,47.5 99.2,47.5 100.06,46.64 100.06,46.1 100.19,45.97 U7.43
  L03_SIG1 w0.091: v1(108.84,5.58) 109.26,5.15 109.26,4.38 108.83,3.95 105.38,3.95 104.55,4.79 104.55,6.93 102.13,9.34 102.13,18.88 101.34,19.68 101.34,26.74 100.73,27.35 100.73,36.65 99.9,37.48 99.9,46.64 v1(98.67,47.87)
  BOTTOM w0.147: J15.172 108.84,3.92 108.38,4.37 108.38,5.12 v1(108.84,5.58)
PORZ: length 261
  TOP w0.147: v1(67.81,12.05) 67.93,11.93 R419.1 ; 34.89,32 35.19,32.3 v1(37.19,32.3) 37.7,32.3 38.37,31.62 38.37,27.2 39.32,26.25 40.3,26.25 41.12,25.44 47.56,25.44 50.98,22.02 61.25,22.02 62.05,22.83 66.13,22.83 69.65,26.35 81.1,26.35 v1(82.01,27.27) 82.21,27.06 TP75.1 83.51,27.06 84.79,28.35 U79.4 86.39,28.99 86.62,29.22 86.62,33.55 86.9,33.83 86.9,35.71 v1(86.22,36.38) ; 34.89,32 Q21.1 ; 34.89,32 32.93,33.97 27.87,33.97 26.8,32.9 24.39,32.9 21.91,35.37 21.91,52.66 25.77,56.51 25.77,60.89 27.7,62.82 27.7,63.65 26.9,64.45 26.9,66.67 28.66,68.43 41.14,68.43 45.95,73.24 45.95,74.38 46.62,75.05 46.62,77.77 45.75,78.64 45.75,85.2 48.86,88.3 51.67,88.3 53.96,90.6 55.11,90.6 56.69,92.18 v1(57.4,92.18) 57.4,91.1 58.2,90.3 61.94,90.3 63.55,91.91 67.18,91.91 67.54,92.26 67.54,99.86 v1(68,100.32) ; U1.R2 v1(53.78,35.23) ; U36.2 v1(80.76,39.79)
  L08_SIG2 w0.091: v1(53.78,35.23) 53.17,35.23 52.64,34.7 49.9,34.7 48.54,33.34 41.81,33.34 40.77,32.3 v1(37.19,32.3) ; v1(67.81,12.05) 69.76,14 76.06,14 82.09,20.03 82.09,27.19 v1(82.01,27.27)
  BOTTOM w0.147: v1(53.78,35.23) 53.4,34.85 53.4,34.72 52.92,34.25 R187.1 ; U21.2 32.61,36.27 32.98,35.9 32.98,34.67 33.38,34.26 36.3,34.26 37.19,33.38 v1(37.19,32.3) ; v1(68,100.32) U39.2 ; v1(86.22,36.38) 82.11,36.38 81.21,35.48 80.59,35.48 80.05,36.01 80.05,39.08 v1(80.76,39.79) ; R327.1 v1(57.4,92.18)
PORZ_RST: length 159
  TOP w0.147: U78.3 v1(80.19,32.03)
  L03_SIG1 w0.091: v1(104.95,97.59) 104.95,103.58 100.4,108.12 81.23,108.12 75.29,102.18 71.4,102.18 70.47,103.11 67.89,103.11 67.17,102.39 57.06,102.39 v1(52.9,98.23)
  L08_SIG2 w0.091: v1(104.95,97.59) 105.78,96.75 105.78,83.33 99.94,77.49 92.27,77.49 91.94,77.82 90.99,77.82 90.72,77.55 90.72,76.63 94.82,72.52 94.82,66.37 95.56,65.63 95.56,49.96 v1(96.61,48.91)
  BOTTOM w0.147: v1(96.61,48.91) 86.81,39.11 86.81,36.2 86.44,35.84 83.08,35.84 82.03,34.79 82.03,32.95 81.11,32.03 v1(80.19,32.03) ; U76.7 53.06,95.09 52.9,95.25 R427.2 v1(52.9,98.23)
PORZ_VMAIN: length 1.8
  TOP w0.147: U78.4 U79.1
PR0_IEP0_EDC_SYNC_OUT0: length 2
  TOP w0.147: R420.1 J16.1
PR0_IEP0_EDC_SYNC_OUT1: length 10.4
  TOP w0.147: R422.1 63.82,53.34 64.28,53.79 64.28,54.88 J18.1
PR0_IEP0_EDIO_DATA_IN_OUT30: length 12.5
  BOTTOM w0.147: R421.1 63.68,54.92 62.08,56.52 62.08,62.22 63.81,63.95 J17.1
PR0_IEP0_EDIO_DATA_IN_OUT31: length 2.4
  TOP w0.147: J19.1 67.96,18.09 68.45,17.61 R423.1
PR0_MDIO0_MDC: length 21.2
  TOP w0.147: R211.2 73.96,37.22 v1(74.47,36.71) ; R470.2 v1(77.35,29.38)
  L03_SIG1 w0.091: v1(74.47,36.71) 73.86,37.31 73.86,37.81 74.25,38.2 74.72,38.2 76.64,36.27 76.64,30.09 v1(77.35,29.38)
  BOTTOM w0.147: R470.2 v1(77.35,29.38) ; v1(74.47,36.71) 75.59,37.83 77.5,37.83 77.9,37.43 U90.2
PR0_MDIO0_MDC_ADD: length 87.7
  TOP w0.147: J8.20 71.79,91.44 v1(71.53,91.19)
  L08_SIG2 w0.091: v1(68.28,79.8) 67.43,80.65 67.43,83.4 68.38,84.34 69.93,84.34 70.3,84.71 70.3,85.25 71.53,86.48 v1(71.53,91.19)
  BOTTOM w0.147: v1(68.28,79.8) 67.81,79.32 65.42,79.32 64.64,80.11 63.8,80.11 62.45,78.75 62.45,72.01 60.9,70.46 60.9,67.65 61.6,66.95 64.98,66.95 65.35,66.58 65.35,64.17 63.32,62.14 63.32,57.15 68.02,52.45 71.09,52.45 72.03,51.52 72.03,49.78 71.78,49.53 71.78,48.12 71.96,47.95 72.29,47.62 74.39,47.62 74.85,47.16 76.07,47.16 76.59,46.64 76.59,45.55 75.75,44.7 75.75,41.18 73.39,38.82 73.39,34.96 74.23,34.12 75.1,34.12 75.37,34.4 R3867.2 76.77,34.96 76.9,35.09 U90.4
PR0_MDIO0_MDC_ON: length 62.9
  L08_SIG2 w0.091: v1(89.53,75.15) 89.92,75.15 91.35,73.72 91.35,64.02 93.06,62.31 93.06,58.3 92.47,57.71 92.47,49.58 90.53,47.64 90.53,39.6 v1(86.22,35.29)
  BOTTOM w0.147: v1(86.22,35.29) 85.7,34.76 85.7,34 85.41,33.72 85.41,30.6 83.76,28.94 R472.2 77.52,28.94 76.96,28.38 U81.4 ; U35.42 88.92,73.64 89.53,74.25 v1(89.53,75.15)
PR0_MDIO0_MDIO: length 20.9
  TOP w0.147: R208.2 v1(74.47,34.7) ; v1(70.68,28.88) 71.34,28.88 71.74,28.48 R471.2
  L03_SIG1 w0.091: v1(70.68,28.88) 70.68,29.27 72.69,31.28 73.51,31.28 74.91,32.68 74.91,34.26 v1(74.47,34.7)
  BOTTOM w0.147: U81.8 v1(70.68,28.88) ; v1(74.47,34.7) 73.81,35.36 73.81,37.76 74.45,38.4 76.84,38.4 77.4,38.96 U90.8
PR0_MDIO0_MDIO_ADD: length 78.2
  TOP w0.147: J8.22 v1(73.27,91.84)
  L08_SIG2 w0.091: v1(73.27,91.84) 71.96,90.53 71.96,85.08 70.9,84.02 68.33,84.02 67.63,83.32 67.63,81.09 68.73,79.99 68.73,79.34 v1(68.28,78.89)
  BOTTOM w0.147: v1(68.28,78.89) 65.3,78.89 64.51,79.68 63.79,79.68 62.74,78.63 62.74,71.89 61.2,70.34 61.2,67.77 61.72,67.25 65.1,67.25 65.65,66.7 65.65,64.05 63.61,62.02 63.61,57.27 68.14,52.75 71.21,52.75 72.32,51.64 72.32,49.59 72.2,49.47 72.2,48.12 72.41,47.91 74.52,47.91 74.98,47.45 76.19,47.45 77.19,46.46 77.19,42.26 76.99,42.07 R3866.2 U90.6
PR0_MDIO0_MDIO_ON: length 76
  L08_SIG2 w0.091: v1(86.22,34.32) 85.78,34.77 85.78,36.92 90.29,41.43 90.29,47.75 92.22,49.68 92.22,57.81 92.81,58.4 92.81,61.19 90.31,63.69 90.31,65.16 90.93,65.79 90.93,73.5 90.16,74.28 89.63,74.28 v1(88.36,73.01)
  BOTTOM w0.147: v1(88.36,73.01) 88.42,72.95 U35.41 ; U81.6 70.55,27.88 R473.2 70.15,26.9 70.33,26.72 77.33,26.72 77.67,27.06 77.67,27.5 77.52,27.65 77.52,28.13 77.72,28.33 78.3,28.33 78.84,27.79 80.94,27.79 81.33,28.18 86.23,28.18 87.7,29.65 87.7,33.4 86.78,34.32 v1(86.22,34.32)
PR0_PRU0_GPIO0: length 35.3
  TOP w0.147: U1.K17 v1(66.58,39.23) ; U87.2 v1(79.01,56.89)
  L03_SIG1 w0.091: v1(66.58,39.23) 67.03,38.78 69.26,38.78 69.63,39.16 72.65,39.16 73.18,39.69 73.83,39.69 79.68,45.54 79.68,50.46 80.93,51.71 80.93,58.12 80.67,58.38 80.37,58.38 80.22,58.24 80.22,57.69 80.12,57.59 79.83,57.59 79.72,57.7 79.72,58.25 79.59,58.38 79.17,58.38 79.01,58.23 v1(79.01,56.89)
PR0_PRU0_GPIO1: length 35.2
  TOP w0.147: v1(79.74,56.45) 79.74,56.86 79.2,57.39 U87.3 ; U1.K18 v1(67.38,39.23)
  L03_SIG1 w0.091: v1(79.74,56.45) 80.58,55.61 80.58,51.75 79.41,50.57 79.41,45.88 78.75,45.22 78.6,45.22 78.31,45.51 78.16,45.51 78.05,45.4 78.05,45.25 78.34,44.96 78.34,44.81 78.23,44.71 78.08,44.71 77.79,44.99 77.64,44.99 77.54,44.88 77.54,44.73 77.82,44.45 77.82,44.29 77.71,44.19 77.56,44.19 77.28,44.47 77.12,44.47 77.02,44.36 77.02,44.21 77.3,43.93 77.3,43.78 76.46,42.93 76.31,42.93 76.13,43.11 75.98,43.11 75.88,43 75.88,42.85 76.05,42.68 76.05,42.52 75.94,42.42 75.79,42.42 75.62,42.59 75.46,42.59 75.36,42.48 75.36,42.33 75.53,42.16 75.53,42.01 75.42,41.9 75.27,41.9 75.1,42.07 74.95,42.07 74.84,41.97 74.84,41.81 75.01,41.64 75.01,41.49 74.91,41.38 74.75,41.38 74.58,41.56 74.43,41.56 74.32,41.45 74.32,41.3 74.5,41.12 74.5,40.97 74.39,40.87 74.24,40.87 74.06,41.04 73.91,41.04 73.81,40.93 73.81,40.78 73.98,40.61 73.98,40.45 73.71,40.18 70.12,40.18 69.17,39.23 v1(67.38,39.23)
PR0_PRU0_GPIO2: length 35.3
  TOP w0.147: v1(79.27,54.97) 80.19,55.9 80.19,57 79.3,57.89 U87.4 ; U1.J18 v1(67.38,40.83)
  L03_SIG1 w0.091: v1(79.27,54.97) 78.3,54.01 78.3,53.58 78.19,53.47 77.44,53.47 77.33,53.36 77.33,53.21 77.43,53.1 78.19,53.1 78.3,53 78.3,52.84 78.19,52.74 77.44,52.74 77.33,52.63 77.33,52.48 77.43,52.37 78.19,52.37 78.53,52.03 78.53,49.29 78.02,48.78 77.44,48.78 77.2,49.02 77.2,50.89 77,51.09 76.71,51.09 76.47,50.85 76.47,47.84 75.62,46.98 75.47,46.98 75.19,47.26 75.04,47.26 74.93,47.15 74.93,47 75.21,46.73 75.21,46.57 74.45,45.82 73.86,45.82 68.87,40.83 v1(67.38,40.83)
PR0_PRU0_GPIO3: length 35.1
  TOP w0.147: U87.5 79.69,58.39 80.52,57.56 80.52,55.57 79.4,54.46 78.79,54.46 v1(78.14,55.11) ; U1.J17 v1(66.58,40.83)
  L03_SIG1 w0.091: v1(78.14,55.11) 77.6,55.11 76.09,53.6 76.09,52.78 75.99,52.67 75.42,52.67 75.31,52.57 75.31,52.42 75.42,52.31 75.99,52.31 76.09,52.2 76.09,52.05 75.99,51.94 75.42,51.94 75.31,51.84 75.31,51.68 75.42,51.58 75.99,51.58 76.09,51.47 76.09,50.48 75.99,50.38 75.58,50.38 75.47,50.27 75.47,50.12 75.58,50.01 75.99,50.01 76.09,49.9 76.09,49.36 75.79,49.05 75.63,49.05 75.25,49.44 75.1,49.44 74.99,49.33 74.99,49.18 75.38,48.79 75.38,48.64 75.27,48.54 75.12,48.54 74.74,48.92 74.58,48.92 74.48,48.81 74.48,48.66 74.86,48.28 74.86,48.13 74.58,47.84 74.58,46.73 74.11,46.26 73.03,46.26 70.4,43.63 69.94,43.63 67.52,41.22 67.2,41.22 66.81,40.83 v1(66.58,40.83)
PR0_PRU0_GPIO4: length 35.2
  TOP w0.147: U87.6 v1(79.01,58.89) ; U1.K16 v1(65.78,39.23)
  L03_SIG1 w0.091: v1(79.01,58.89) 78.57,58.45 78.57,56.68 78.84,56.41 79.15,56.41 80.31,55.26 80.31,51.87 79.13,50.69 79.13,47.82 78.84,47.53 78.69,47.53 78.54,47.69 78.39,47.69 78.28,47.58 78.28,47.43 78.43,47.28 78.43,47.12 78.33,47.02 78.17,47.02 78.02,47.17 77.87,47.17 77.76,47.06 77.76,46.91 77.92,46.76 77.92,46.61 77.81,46.5 77.66,46.5 77.5,46.65 77.35,46.65 77.24,46.55 77.24,46.4 77.4,46.24 77.4,46.09 77.29,45.98 77.14,45.98 76.99,46.14 76.83,46.14 76.73,46.03 76.73,45.88 76.88,45.72 76.88,45.57 76.77,45.47 76.62,45.47 76.47,45.62 76.32,45.62 76.21,45.51 76.21,45.36 76.36,45.21 76.36,45.06 76.26,44.95 76.1,44.95 75.95,45.1 75.8,45.1 75.69,45 75.69,44.84 75.85,44.69 75.85,44.54 75.74,44.43 75.59,44.43 75.43,44.59 75.28,44.59 75.17,44.48 75.17,44.33 75.33,44.17 75.33,44.02 75.03,43.72 72.84,43.72 69.28,40.16 68.19,40.16 67.76,39.73 66.28,39.73 v1(65.78,39.23)
PR0_PRU0_GPIO5: length 35.6
  TOP w0.147: U87.7 79.43,59.39 v1(79.93,58.89) ; U1.G17 v1(66.58,42.43)
  L03_SIG1 w0.091: v1(66.58,42.43) 71.4,47.25 71.4,48.75 73.48,50.83 73.48,52.79 75.21,54.52 75.21,59.48 75.49,59.76 77.4,59.76 77.83,60.19 77.83,62.15 78.45,62.78 78.45,63.02 78.81,63.38 79.22,63.38 79.44,63.16 79.44,62.74 79.8,62.38 80.12,62.38 80.36,62.14 80.36,61.38 80.57,61.17 80.57,59.54 v1(79.93,58.89)
PR0_PRU0_GPIO6: length 35.5
  TOP w0.147: U87.11 79.43,61.39 v1(79.93,61.89) ; U1.K15 v1(64.98,39.23)
  L03_SIG1 w0.091: v1(79.93,61.89) 79.46,61.42 79.46,60.4 78.85,59.8 78.85,59.35 78.3,58.8 78.3,55.94 78.8,55.44 79.47,55.44 79.74,55.17 79.74,51.68 78.86,50.8 78.86,48.85 74,43.99 72.65,43.99 69.1,40.44 68.08,40.44 67.64,40 65.75,40 v1(64.98,39.23)
PR0_PRU0_GPIO8: length 35.1
  TOP w0.147: U87.12 v1(79.01,61.89) ; U1.G15 v1(64.98,42.43)
  L03_SIG1 w0.091: v1(64.98,42.43) 65.38,42.83 65.96,42.83 66.19,42.59 66.19,42.25 66.42,42.02 67.57,42.02 69.77,44.21 70.49,44.21 71.04,44.76 71.04,44.92 70.66,45.3 70.66,45.45 70.77,45.56 70.92,45.56 71.3,45.17 71.45,45.17 71.56,45.28 71.56,45.43 71.18,45.82 71.18,45.97 71.28,46.08 71.43,46.08 71.82,45.69 71.97,45.69 72.08,45.8 72.08,45.95 71.69,46.34 71.69,46.49 71.8,46.6 71.95,46.6 72.34,46.21 72.49,46.21 72.6,46.32 72.6,46.47 72.21,46.85 72.21,47.01 72.32,47.11 72.47,47.11 72.86,46.73 73.01,46.73 73.7,47.42 73.7,47.86 73.32,48.23 73.32,49.19 74.89,50.76 74.89,52.81 78.02,55.94 78.02,58.99 78.51,59.47 78.51,61.39 v1(79.01,61.89)
PR0_PRU0_GPIO9: length 30.9
  TOP w0.147: U1.F17 v1(66.58,43.23) ; v1(79.93,62.89) 79.43,62.39 U87.13
  L03_SIG1 w0.091: v1(66.58,43.23) 68.78,45.43 68.78,47.81 72.1,51.13 72.1,52.01 74.93,54.84 74.93,61.64 75.41,62.11 77.36,62.11 78.03,62.78 78.03,62.99 78.7,63.66 79.54,63.66 79.93,63.27 v1(79.93,62.89)
PR0_PRU0_GPIO10: length 26.7
  TOP w0.147: U1.G18 v1(67.38,42.43) ; U87.14 v1(79.01,62.89)
  L03_SIG1 w0.091: v1(79.01,62.89) 78.17,62.05 78.17,59.92 77.75,59.51 77.75,56.33 73.93,52.51 73.93,50.7 71.75,48.52 71.75,47.17 67.38,42.8 v1(67.38,42.43)
PR0_PRU0_GPIO11: length 79.9
  TOP w0.147: U1.M16 v1(65.78,37.63)
  L03_SIG1 w0.091: v1(65.78,37.63) 65.38,37.23 63.16,37.23 62.97,37.42 62.97,39.48 62.76,39.69 61.35,39.69 60.58,40.46 60.58,47.01 60.86,47.29 60.86,52.87 61.63,53.64 61.63,62.51 62.4,63.28 62.4,66.16 66.4,70.16 69.23,70.16 73.1,74.03 73.1,75.92 77.32,80.14 77.32,97.19 79.96,99.84 v1(80.39,99.84)
  BOTTOM w0.147: U88.4 80.89,99.34 v1(80.39,99.84)
PR0_PRU0_GPIO12: length 79.7
  TOP w0.147: U1.M15 v1(64.98,37.63)
  L03_SIG1 w0.091: v1(81.3,99.84) 80.81,99.34 80.09,99.34 77.59,96.84 77.59,80.06 73.37,75.84 73.37,73.97 69.28,69.88 66.51,69.88 62.67,66.05 62.67,63.16 61.91,62.4 61.91,54.52 64.02,52.4 64.02,51.58 63.67,51.23 63.52,51.23 63.32,51.43 63.17,51.43 63.06,51.32 63.06,51.17 63.26,50.97 63.26,50.82 63.15,50.71 63,50.71 62.8,50.91 62.65,50.91 62.54,50.8 62.54,50.65 62.74,50.45 62.74,50.3 61.38,48.94 61.38,40.62 62.08,39.92 63.31,39.92 63.79,39.43 63.79,38.27 64.03,38.03 64.58,38.03 v1(64.98,37.63)
  BOTTOM w0.147: U88.5 v1(81.3,99.84)
PR0_PRU0_GPIO13: length 80
  TOP w0.147: U1.H17 v1(66.58,41.63)
  L03_SIG1 w0.091: v1(66.58,41.63) 66.41,41.63 66.02,41.24 64.02,41.24 63.78,41.48 63.78,47.64 64.41,48.27 66.4,48.27 66.89,48.75 66.89,52.04 62.71,56.21 62.71,61.46 65.46,64.21 65.46,64.97 74.1,73.61 74.1,75.37 75.35,76.62 76.62,76.62 77.19,77.18 78.57,77.18 78.69,77.31 78.69,93.33 80.04,94.68 80.04,96.58 80.65,97.19 81.34,97.19 81.94,97.78 81.94,99.89 81.48,100.34 80.88,100.34 v1(80.39,100.84)
  BOTTOM w0.147: v1(80.39,100.84) 80.89,100.34 U88.6
PR0_PRU0_GPIO14: length 80.3
  TOP w0.147: U1.H16 v1(65.78,41.63)
  L03_SIG1 w0.091: v1(65.78,41.63) 65.39,42.02 64.84,42.02 64.59,42.27 64.59,47.57 64.93,47.9 65.96,47.9 66.28,47.58 66.28,45.68 66.43,45.53 66.64,45.53 66.78,45.67 66.78,47.48 67.18,47.87 67.18,52.16 63,56.33 63,61.36 65.74,64.1 65.74,64.86 74.31,73.43 74.31,75.13 75.39,76.21 78.53,76.21 78.92,76.61 78.92,93.11 80.34,94.53 80.34,96.18 81.03,96.87 81.41,96.87 82.21,97.67 82.21,100.3 81.67,100.84 v1(81.3,100.84)
  BOTTOM w0.147: U88.7 v1(81.3,100.84)
PR0_PRU0_GPIO15: length 79.9
  TOP w0.147: U1.L16 v1(65.78,38.43)
  L03_SIG1 w0.091: v1(65.78,38.43) 65.39,38.82 64.79,38.82 64.59,39.02 64.59,39.67 64.05,40.21 62.57,40.21 62.18,40.6 62.18,48.14 62.45,48.42 62.45,48.57 62.1,48.92 62.1,49.08 62.2,49.18 62.36,49.18 62.71,48.83 62.86,48.83 62.97,48.93 62.97,49.08 62.61,49.44 62.61,49.59 62.72,49.7 62.87,49.7 63.23,49.34 63.38,49.34 63.49,49.45 63.49,49.6 63.13,49.96 63.13,50.11 63.24,50.22 63.39,50.22 63.75,49.86 63.9,49.86 64.01,49.97 64.01,50.12 63.65,50.48 63.65,50.63 63.76,50.73 63.91,50.73 64.26,50.38 64.42,50.38 64.58,50.54 64.58,52.23 62.18,54.63 62.18,61.68 64.93,64.43 64.93,65.19 73.61,73.88 73.61,75.66 78.15,80.2 78.15,93.78 79.26,94.89 79.26,97.71 v1(80.39,98.84)
  BOTTOM w0.147: U88.2 80.89,98.34 v1(80.39,98.84)
PR0_PRU0_GPIO16: length 79.7
  TOP w0.147: U1.H18 v1(67.38,41.63)
  L03_SIG1 w0.091: v1(67.38,41.63) 67.17,41.42 66.98,41.42 66.8,41.24 66.37,41.24 66.18,41.06 66.18,40.61 65.98,40.41 63.2,40.41 62.98,40.63 62.98,47.5 63.21,47.73 63.21,47.88 62.96,48.12 62.96,48.27 63.07,48.38 63.22,48.38 63.47,48.14 63.62,48.14 63.72,48.24 63.72,48.39 63.48,48.64 63.48,48.79 63.59,48.9 63.74,48.9 63.98,48.65 64.13,48.65 64.24,48.76 64.24,48.91 64,49.16 64,49.31 64.11,49.41 64.26,49.41 64.5,49.17 64.65,49.17 64.76,49.28 64.76,49.43 64.52,49.67 64.52,49.82 64.62,49.93 64.77,49.93 65.02,49.69 65.17,49.69 65.28,49.79 65.28,49.95 65.03,50.19 65.03,50.34 65.14,50.45 65.29,50.45 65.53,50.2 65.69,50.2 65.93,50.45 65.93,52.54 62.44,56.03 62.44,61.57 65.19,64.32 65.19,65.09 73.87,73.77 73.87,75.55 78.43,80.1 78.43,93.59 79.62,94.78 79.62,97.16 v1(81.3,98.84)
  BOTTOM w0.147: U88.3 v1(81.3,98.84)
PR0_PRU0_REF_CLK: length 118.9
  TOP w0.147: v1(18.79,33.49) 16.39,33.49 16.23,33.65 R272.2
  L03_SIG1 w0.091: v1(18.79,33.49) 18.79,58.87 25.08,65.17 41.01,65.17 v1(43.31,62.87)
  L08_SIG2 w0.091: v1(43.31,62.87) 49.08,62.87 49.45,63.24 50.11,63.24 53.46,59.89 53.46,58.88 54.97,57.37 63.61,57.37 65.11,58.87 65.53,58.87 66.02,58.37 66.37,58.37 66.63,58.11 66.63,56.9 67.42,56.11 68.96,56.11 69.29,55.78 70.38,55.78 71.8,54.36 81.34,54.36 82.85,55.87 86.19,55.87 91.05,60.74 91.05,61.62 v1(88.42,64.25)
  BOTTOM w0.147: U35.20 v1(88.42,64.25)
PR0_PRU1_GPIO0: length 57.5
  BOTTOM w0.147: R247.2 77.93,50.27 78.24,49.96 78.24,44.76 78.59,44.4 81.62,44.4 82.19,44.98 82.19,45.83 81.71,46.3 81.3,46.3 80.62,46.98 80.62,50.97 85.82,56.17 85.82,61.54 81.46,65.9 81.46,70.25 82.67,71.47 82.67,79.96 81.99,80.65 81.99,84.1 81.41,84.68 81.41,85.08 81.67,85.35 U89.2
PR0_PRU1_GPIO1: length 57
  TOP w0.147: R248.2 77.52,50.27 v1(78.04,50.79)
  BOTTOM w0.147: v1(78.04,50.79) 78.67,50.16 78.67,45.09 78.94,44.83 80.92,44.83 81.28,45.19 81.28,45.63 80.33,46.59 80.33,51.27 85.27,56.22 85.27,61.63 81.13,65.77 81.13,70.39 82.35,71.61 82.35,79.83 81.67,80.5 81.67,83.99 81.02,84.65 81.02,85.41 81.46,85.85 U89.3
PR0_PRU1_GPIO2: length 57.6
  TOP w0.147: v1(75.64,51.05) R249.2
  BOTTOM w0.147: v1(75.64,51.05) 75.18,51.05 75,51.23 75,51.74 75.67,52.41 77.42,52.41 79.08,50.75 79.08,46.67 79.26,46.48 79.61,46.48 79.83,46.71 79.83,51.36 84.86,56.4 84.86,61.58 80.81,65.63 80.81,70.52 82.02,71.74 82.02,79.69 81.36,80.35 81.36,83.88 80.61,84.63 80.61,85.5 81.46,86.35 U89.4
PR0_PRU1_GPIO3: length 57.1
  TOP w0.147: v1(81.3,86.85) 82.23,85.92 84.9,85.92 85.35,85.47 85.35,84.86 86.19,84.02 86.19,80.94 87.16,79.96 87.16,79.78 86.84,79.45 86.84,79.27 86.97,79.14 87.15,79.14 87.48,79.47 87.66,79.47 87.79,79.34 87.79,79.15 87.46,78.83 87.46,78.65 87.59,78.52 87.77,78.52 88.1,78.84 88.28,78.84 88.72,78.41 88.72,74.58 87.56,73.42 87.56,71.5 88.37,70.68 88.37,66.04 86.44,64.11 84.31,64.11 83.85,63.65 83.85,63.24 83.98,63.11 84.47,63.11 84.6,62.98 84.6,62.8 84.47,62.67 83.98,62.67 83.85,62.54 83.85,62.36 83.98,62.23 84.47,62.23 84.6,62.1 84.6,61.92 84.47,61.79 83.98,61.79 83.85,61.66 83.85,61.47 83.98,61.35 84.47,61.35 84.6,61.22 84.6,61.03 84.47,60.9 83.98,60.9 83.85,60.77 83.85,60.32 83.12,59.58 83.12,54.83 80,51.71 v1(76.86,51.71)
  BOTTOM w0.147: R250.2 75.76,50.27 76.24,50.74 76.24,51.09 v1(76.86,51.71) ; U89.5 v1(81.3,86.85)
PR0_PRU1_GPIO4: length 57.5
  TOP w0.147: R251.2 v1(74.42,51.05)
  BOTTOM w0.147: U89.6 81.08,87.35 80.2,86.47 80.2,84.62 81.05,83.77 81.05,80.21 81.7,79.56 81.7,71.87 80.48,70.66 80.48,65.5 84.43,61.55 84.43,56.78 84.13,56.49 83.95,56.49 83.61,56.83 83.42,56.83 83.29,56.7 83.29,56.52 83.64,56.17 83.64,55.99 83.51,55.86 83.33,55.86 82.98,56.2 82.8,56.2 82.67,56.08 82.67,55.89 83.01,55.55 83.01,55.37 82.88,55.24 82.7,55.24 82.36,55.58 82.17,55.58 82.04,55.45 82.04,55.27 82.39,54.92 82.39,54.74 82.26,54.61 82.08,54.61 81.73,54.95 81.55,54.95 81.42,54.83 81.42,54.64 81.76,54.3 81.76,54.12 81.63,53.99 81.45,53.99 81.11,54.33 80.92,54.33 80.79,54.2 80.79,54.02 81.14,53.67 81.14,53.49 81.01,53.36 80.83,53.36 80.48,53.7 80.3,53.7 80.17,53.58 80.17,53.39 80.35,53.21 80.35,53 80.2,52.85 79.85,52.85 79.72,52.73 79.72,52.26 79.59,52.13 79.41,52.13 79.28,52.26 79.28,52.73 79.15,52.85 78.97,52.85 78.84,52.73 78.84,52.26 78.71,52.13 78.53,52.13 78.4,52.26 78.4,52.73 78.27,52.85 75.39,52.85 74.42,51.88 v1(74.42,51.05)
PR0_PRU1_GPIO5: length 57.6
  TOP w0.147: v1(71.23,51.05) 72.38,52.19 80.06,52.19 82.79,54.92 82.79,59.93 v1(83.32,60.45)
  BOTTOM w0.147: v1(71.23,51.05) 70.85,50.67 R252.2 ; U89.7 80.93,87.85 79.79,86.7 79.79,84.62 80.74,83.67 80.74,80.06 81.37,79.42 81.37,72.01 80.16,70.79 80.16,65.37 84.02,61.5 84.02,57.93 83.81,57.71 83.52,57.71 83.32,57.92 v1(83.32,60.45)
PR0_PRU1_GPIO6: length 57.2
  TOP w0.147: v1(81.33,89.85) 82.93,88.25 84.82,88.25 85.77,87.3 85.77,85.06 86.5,84.33 86.5,81.07 89.03,78.54 89.03,74.45 87.86,73.29 87.86,71.63 88.68,70.81 88.68,65.84 87.17,64.33 87.17,63.07 83.44,59.35 83.44,54.73 79.99,51.27 77.44,51.27 77.34,51.18 76.41,51.18 76.08,51.51 72.46,51.51 71.98,51.02 R253.2
  BOTTOM w0.147: U89.11 v1(81.33,89.85)
PR0_PRU1_GPIO8: length 57.1
  BOTTOM w0.147: R254.2 74.39,50.27 73.81,50.85 73.81,51.93 75.66,53.78 76.2,53.78 76.33,53.66 76.33,53.52 76.46,53.39 76.64,53.39 76.77,53.52 76.77,53.66 76.9,53.78 77.09,53.78 77.21,53.66 77.21,53.52 77.34,53.39 77.53,53.39 77.66,53.52 77.66,53.66 77.79,53.78 77.97,53.78 78.1,53.66 78.1,53.52 78.23,53.39 78.41,53.39 78.54,53.52 78.54,53.66 78.67,53.78 79.64,53.78 82.64,56.79 82.64,57.52 82.51,57.65 82.2,57.65 82.08,57.78 82.08,57.96 82.2,58.09 82.51,58.09 82.64,58.22 82.64,58.4 82.51,58.53 82.2,58.53 82.08,58.66 82.08,58.85 82.2,58.98 82.51,58.98 82.64,59.11 82.64,59.29 82.51,59.42 82.2,59.42 82.08,59.55 82.08,59.73 82.2,59.86 82.51,59.86 82.64,59.99 82.64,60.17 82.51,60.3 82.2,60.3 82.08,60.43 82.08,60.61 82.2,60.74 82.51,60.74 82.64,60.87 82.64,61.06 82.51,61.19 82.2,61.19 82.08,61.31 82.08,61.5 82.2,61.63 82.51,61.63 82.64,61.76 82.64,62.42 79.83,65.23 79.83,70.93 81.05,72.14 81.05,79.29 80.42,79.91 80.42,83.56 78.96,85.03 78.96,89.35 79.95,90.35 U89.12
PR0_PRU1_GPIO9: length 51.4
  BOTTOM w0.147: U89.13 79.85,90.85 78.6,89.6 78.6,84.97 80.11,83.46 80.11,79.76 80.72,79.15 80.72,72.28 79.5,71.06 79.5,65.1 81.6,63 81.6,56.66 79.36,54.42 75.53,54.42 73.47,52.37 73.47,51.03 73.21,50.77 R255.2
PR0_PRU1_GPIO10: length 49.9
  TOP w0.147: v1(72.83,51.05) 73.2,50.68 R256.2
  BOTTOM w0.147: U89.14 79.77,91.35 78.25,89.83 78.25,84.9 79.8,83.36 79.8,79.62 80.4,79.02 80.4,72.41 79.18,71.2 79.18,64.96 79.62,64.52 79.62,63.39 79.47,63.23 79.47,60.24 78.11,58.88 78.11,58.14 77.5,57.53 75.32,57.53 72.83,55.05 v1(72.83,51.05)
PR0_PRU1_GPIO11: length 72.2
  TOP w0.147: v1(80.39,103.34) 80.61,103.11 80.61,102.79 80.43,102.62 80.19,102.62 79.98,102.82 79.72,102.82 79.54,102.64 79.54,97.8 80.19,97.15 80.19,88.86 80.89,88.16 80.89,87.71 80.41,87.22 80.41,86.53 81.45,85.49 81.45,81.9 82.07,81.28 82.07,77.95 83.32,76.7 84.02,76.7 84.17,76.55 84.17,76.17 83.56,75.56 82.45,75.56 81.89,74.99 81.89,70.92 81.15,70.17 81.15,65.61 82.93,63.82 82.93,61.3 82.14,60.51 82.14,55.11 79.84,52.81 71.26,52.81 70.01,51.56 v1(70.01,51.05)
  BOTTOM w0.147: v1(80.39,103.34) 80.89,102.84 U88.11 ; R257.2 69.63,50.67 v1(70.01,51.05)
PR0_PRU1_GPIO12: length 71.9
  TOP w0.147: R258.2 69.54,50.83 69.32,51.05 69.32,51.44 70.99,53.11 79.74,53.11 81.82,55.2 81.82,60.68 82.58,61.45 82.58,63.68 80.81,65.45 80.81,70.31 81.54,71.04 81.54,75.14 82.37,75.97 83.01,75.97 83.16,76.12 83.16,76.33 82.81,76.67 82.63,76.67 82.47,76.5 82.28,76.5 82.15,76.63 82.15,76.82 82.32,76.98 82.32,77.16 81.67,77.82 81.67,79.62 81.54,79.75 81.33,79.75 81.2,79.88 81.2,80.07 81.33,80.19 81.54,80.19 81.67,80.32 81.67,81.23 81.1,81.8 81.1,85.39 79.88,86.61 79.88,96.81 79.19,97.5 79.19,102.92 80.06,103.79 80.85,103.79 v1(81.3,103.34)
  BOTTOM w0.147: U88.12 v1(81.3,103.34)
PR0_PRU1_GPIO13: length 71.8
  TOP w0.147: v1(80.39,104.34) 79.93,104.34 78.84,103.24 78.84,97.2 79.57,96.47 79.57,86.42 80.75,85.25 80.75,81.23 80.88,81.1 81.09,81.1 81.22,80.98 81.22,80.79 81.09,80.66 80.88,80.66 80.75,80.53 80.75,79.65 81.19,79.21 81.19,77.23 81.32,77.1 81.53,77.1 81.66,76.97 81.66,76.79 81.53,76.66 81.32,76.66 81.19,76.53 81.19,76.35 81.32,76.22 81.53,76.22 81.66,76.09 81.66,75.91 81.53,75.78 81.32,75.78 81.19,75.65 81.19,71.17 80.47,70.45 80.47,65.3 82.23,63.53 82.23,61.59 81.49,60.85 81.49,55.29 79.63,53.42 70.7,53.42 68.79,51.51 v1(68.79,51.05)
  BOTTOM w0.147: U88.13 80.89,103.84 v1(80.39,104.34) ; R259.2 68.41,50.67 v1(68.79,51.05)
PR0_PRU1_GPIO14: length 72
  TOP w0.147: v1(81.3,104.34) 82.05,103.58 82.05,102.97 81.77,102.68 81.19,102.68 79.89,101.39 79.89,98.01 80.52,97.39 80.52,89.06 81.24,88.34 81.24,87.5 80.84,87.11 80.84,86.55 81.8,85.6 81.8,82.01 82.46,81.34 82.46,78.13 83.52,77.08 84.24,77.08 84.61,76.71 84.61,76.08 83.62,75.09 82.48,75.09 82.24,74.85 82.24,70.79 81.48,70.03 81.48,65.77 83.28,63.97 83.28,61.16 82.47,60.34 82.47,55.01 79.95,52.5 71.79,52.5 70.62,51.33 70.62,50.97 70.76,50.83 R260.2
  BOTTOM w0.147: U88.14 v1(81.3,104.34)
PR0_PRU1_GPIO15: length 72.5
  TOP w0.147: v1(80.39,105.34) 80.49,105.44 80.7,105.44 80.85,105.3 80.85,105.15 81.05,104.95 81.05,104.73 80.95,104.63 80.74,104.63 80.58,104.79 79.84,104.79 78.49,103.44 78.49,96.94 79.25,96.18 79.25,86.25 80.4,85.1 80.4,79.5 80.84,79.06 80.84,71.3 80.13,70.59 80.13,65.14 81.88,63.39 81.88,61.74 81.17,61.02 81.17,55.38 79.52,53.73 70.46,53.73 68.32,51.59 R261.2
  BOTTOM w0.147: U88.15 80.89,104.84 v1(80.39,105.34)
PR0_PRU1_GPIO16: length 72.1
  TOP w0.147: v1(67.83,51.05) 67.83,51.71 70.16,54.04 79.41,54.04 80.84,55.47 80.84,61.19 81.53,61.88 81.53,63.24 79.8,64.98 79.8,70.73 80.49,71.42 80.49,78.92 80.04,79.36 80.04,84.96 78.92,86.08 78.92,95.82 78.14,96.61 78.14,103.75 80.2,105.81 80.83,105.81 v1(81.3,105.34)
  BOTTOM w0.147: R262.2 67.19,50.87 67.37,51.05 v1(67.83,51.05) ; U88.16 v1(81.3,105.34)
PR0_PRU1_GPIO18: length 89.5
  TOP w0.147: R1652.2 66.43,51.65 v1(66.43,51.69) ; R423.2 68.94,16.04 69.08,15.9 v1(69.95,15.9)
  L03_SIG1 w0.091: v1(69.95,15.9) 65.18,11.12 65.18,9.31 63.8,7.94 63.8,5.67 63.12,4.99 61.26,4.99 60.41,4.13 50.06,4.13 49.33,4.86 49.33,6.92 v1(48.64,7.61)
  L08_SIG2 w0.091: v1(69.95,15.9) 70.22,15.64 74.75,15.64 77.31,18.19 77.31,24.11 80.12,26.93 80.12,27.56 79.71,27.98 79.71,28.44 78.91,29.24 78.48,29.24 77.22,30.49 77.22,33.81 75.9,35.13 75.9,38.76 75.2,39.46 75.2,44.08 72.12,47.15 72.12,47.96 70.9,49.18 69.52,49.18 68.52,50.19 67.71,50.19 66.69,51.2 66.69,51.43 v1(66.43,51.69)
  BOTTOM w0.147: v1(48.64,7.61) 47.84,6.81 J15.70
PR0_PRU1_GPIO19: length 89.1
  TOP w0.147: R1653.2 v1(65.2,51.69) ; R420.2 71.91,16.24 v1(72.05,16.1)
  L03_SIG1 w0.091: v1(72.05,16.1) 71.04,16.1 66.59,11.66 66.59,9.82 65.64,8.86 65.64,4.57 64.8,3.73 48.87,3.73 48.21,4.38 48.21,4.4 v1(47.04,5.58)
  L08_SIG2 w0.091: v1(65.2,51.69) 66.12,50.77 66.84,50.77 67.66,49.94 68.4,49.94 69.39,48.95 70.51,48.95 71.69,47.78 71.69,46.2 73.6,44.28 74.41,44.28 74.97,43.72 74.97,39.3 75.66,38.61 75.66,35.03 76.82,33.86 76.82,29.2 77.34,28.69 78.08,28.69 78.99,27.78 79.45,27.78 79.79,27.44 79.79,26.98 76.4,23.58 76.4,17.67 74.83,16.1 v1(72.05,16.1)
  BOTTOM w0.147: J15.68 47.04,3.92 47.49,4.37 47.49,5.12 v1(47.04,5.58)
PR0_PRU1_REF_CLK: length 100.2
  TOP w0.147: R274.2 v1(28.89,37.39) ; J8.28 v1(73.27,93.04)
  L08_SIG2 w0.091: v1(28.89,37.39) 27.4,38.89 27.4,46.51 25.88,48.03 25.88,60.78 26.39,61.3 28.7,61.3 29.57,62.17 31.06,62.17 31.74,62.84 40.01,62.84 42.4,65.24 49.13,65.24 49.66,64.7 50.87,64.7 52.4,63.18 57.8,63.18 58.87,64.24 61.93,64.24 62.43,64.74 62.43,76.06 64.98,78.61 64.98,85.54 66.78,87.34 66.78,87.68 69.21,90.11 69.21,91.13 70.89,92.81 73.04,92.81 v1(73.27,93.04)
QSPI_CLK: length 34.4
  TOP w0.147: U18.6 30.27,55.11 30.16,55.21 R89.1 v1(29.66,54.6)
  L08_SIG2 w0.091: v1(41.73,46.76) 41.3,46.33 40.53,46.33 35.01,51.86 34.89,51.86 34.81,51.78 34.81,51.61 39.42,47 39.42,46.89 39.34,46.81 39.23,46.81 34.25,51.78 34.25,53.08 32.73,54.6 v1(29.66,54.6)
  BOTTOM w0.147: v1(41.73,46.76) 41.23,46.26 U80.41
QSPI_CS1: length 28.1
  TOP w0.147: U18.1 40.11,52.57 R86.2 v1(40.67,51.84)
  L03_SIG1 w0.091: v1(46.74,34.95) 46.4,34.61 43.13,34.61 42.05,35.69 42.05,36.34 42.4,36.69 42.4,47.27 40.67,49 v1(40.67,51.84)
  BOTTOM w0.147: R99.1 TP46.1 47.06,34.74 46.84,34.95 v1(46.74,34.95)
QSPI_D0: length 31.6
  TOP w0.147: v1(27.79,58.41) R1667.1 R439.2
  L08_SIG2 w0.091: v1(27.79,58.41) 28.58,57.61 37.46,57.61 38.17,56.9 38.17,52.24 38.25,52.16 38.37,52.16 38.45,52.24 38.45,54.53 38.54,54.62 38.65,54.62 38.73,54.54 38.73,48.75 v1(40.73,46.76)
  BOTTOM w0.147: v1(40.73,46.76) 40.23,46.26 U80.39
QSPI_D1: length 31.9
  TOP w0.147: R440.2 R1668.1 42.83,53.11 v1(42.71,52.99)
  L08_SIG2 w0.091: v1(42.71,52.99) 42.71,54.64 42.62,54.73 41.31,54.73 41.22,54.64 41.22,54.47 41.3,54.39 42.13,54.39 42.21,54.31 42.21,54.2 42.13,54.12 41.3,54.12 41.22,54.04 41.22,53.92 41.3,53.84 42.13,53.84 42.21,53.76 42.21,53.65 42.13,53.57 41.3,53.57 41.22,53.49 41.22,53.38 41.3,53.3 42.13,53.3 42.21,53.21 42.21,53.1 42.13,53.02 41.3,53.02 41.22,52.94 41.22,52.83 41.3,52.75 42.13,52.75 42.21,52.67 42.21,52.55 42.13,52.47 41.3,52.47 41.22,52.39 41.22,48.28 42.61,46.89 42.61,42.49 42.07,41.95 39.83,41.95 39.28,42.51 v1(39.28,44.91)
  BOTTOM w0.147: U80.38 v1(39.28,44.91)
QSPI_D2: length 32.2
  TOP w0.147: v1(42.29,56.12) 42.83,55.58 R84.2 R441.2
  L08_SIG2 w0.091: v1(38.17,43.62) 38.17,44.9 38.75,45.48 39.95,45.48 40.49,44.94 41.89,44.94 42.22,45.28 42.22,46.89 39.84,49.27 39.84,53.78 39.76,53.86 39.65,53.86 39.57,53.78 39.57,49.78 39.49,49.7 39.37,49.7 39.29,49.78 39.29,54.61 40.81,56.12 v1(42.29,56.12)
  BOTTOM w0.147: U80.36 38.47,43.32 v1(38.17,43.62)
QSPI_D3: length 32.7
  TOP w0.147: v1(27.56,54.73) R85.2 R442.2
  L08_SIG2 w0.091: v1(37.21,42.79) 37.5,43.08 37.5,46.58 33.19,50.9 33.19,51.02 33.27,51.1 33.42,51.1 37,47.51 37.12,47.51 37.2,47.59 37.2,47.71 30.95,53.96 28.33,53.96 v1(27.56,54.73)
  BOTTOM w0.147: U80.34 37.67,42.32 v1(37.21,42.79)
R_LED2_0: length 6.6
  BOTTOM w0.147: J7.11 109.27,77.15 107.54,78.88 105.96,78.88 105.6,79.24 R216.1
RBIAS2: length 5.1
  BOTTOM w0.147: U35.12 94.16,65.84 94.74,65.27 TP63.1 R215.1
RESETZ: length 45.8
  L03_SIG1 w0.091: v1(52.36,89.94) 52.36,86.52 50.23,84.4 50.23,79.39 51.03,78.59 51.03,73.3 49.19,71.45 49.19,64.05 48.6,63.46 48.6,57.9 v1(54.33,52.17)
  BOTTOM w0.147: U76.2 53.06,90.02 R428.2 v1(52.36,89.94) ; v1(54.33,52.17) 53.91,51.74 R185.1
RESETZ_HSEC: length 8.4
  TOP w0.147: R419.2 v1(67.93,9.64)
  BOTTOM w0.147: v1(67.93,9.64) 67.21,8.92 67.21,5.54 67.84,4.91 J15.120
RJ45_ETH0_D0_N: length 9.7
  BOTTOM w0.108: J7.10 99.66,74.02 99.66,73.33 98.33,72 96.74,72 95.7,70.95 93.43,70.95 93.32,70.84 U35.2
RJ45_ETH0_D0_P: length 9.7
  BOTTOM w0.108: U35.1 93.32,71.34 93.43,71.24 95.58,71.24 96.62,72.29 98.21,72.29 99.37,73.45 99.37,73.82 99.2,73.98 98.86,73.98 J7.9
RJ45_ETH0_D1_N: length 9.4
  BOTTOM w0.108: U35.5 93.32,69.34 93.43,69.45 98.55,69.45 99.66,70.56 99.66,71.48 J7.8
RJ45_ETH0_D1_P: length 9.4
  BOTTOM w0.108: J7.7 98.86,71.44 99.2,71.44 99.37,71.28 99.37,70.68 98.43,69.74 93.43,69.74 93.32,69.84 U35.4
RJ45_ETH0_D2_N: length 9.8
  BOTTOM w0.108: U35.8 93.32,67.84 93.43,67.95 95.99,67.95 96.93,67.01 98.71,67.01 99.66,67.96 99.66,68.94 J7.6
RJ45_ETH0_D2_P: length 9.8
  BOTTOM w0.108: J7.5 98.86,68.9 99.2,68.9 99.37,68.74 99.37,68.08 98.59,67.3 97.05,67.3 96.11,68.24 93.43,68.24 93.32,68.34 U35.7
RJ45_ETH0_D3_N: length 10.1
  BOTTOM w0.108: J7.4 99.66,66.4 99.66,65.67 98.49,64.5 98.39,64.5 98.39,64.5 97.28,64.5 96.52,64.5 94.57,66.45 93.43,66.45 93.32,66.34 U35.11
RJ45_ETH0_D3_P: length 10.1
  BOTTOM w0.108: U35.10 93.32,66.84 93.43,66.74 94.69,66.74 96.64,64.79 97.4,64.79 97.4,64.79 98.27,64.79 98.27,64.79 98.37,64.79 99.37,65.79 99.37,66.2 99.2,66.36 98.86,66.36 J7.3
RSVD_T4: length 5.9
  TOP w0.147: U1.T4 v1(55.38,34.43)
  BOTTOM w0.114: 55.78,34.03 57.21,34.03 57.38,33.86 57.38,33.37
  BOTTOM w0.147: R82.1 58.11,31.62 57.38,32.34 57.38,33.37 ; 55.78,34.03 v1(55.38,34.43)
RSVD_U1: length 3.9
  TOP w0.147: U1.U1 52.83,33.48 52.83,32.04 52.03,31.25 R186.1
RSVD_U3: length 4.6
  TOP w0.147: TP59.1 53.61,31.41 54.49,32.29 54.49,32.9 54.59,33 54.59,33.64 U1.U3
RSVD_V2: length 5.8
  TOP w0.147: TP60.1 52.7,28.82 52.72,28.83 52.72,31.13 54.18,32.59 U1.V2
SAFETY_ERRORN: length 88.8
  TOP w0.147: U1.D4 v1(55.38,44.83) ; v1(78.02,27.85) 78.02,29.6 77.57,30.06 77.03,30.06 76.62,30.48 Q20.1
  L08_SIG2 w0.091: v1(55.38,44.83) 55.44,44.83 55.83,44.44 58.74,44.44 58.97,44.67 58.97,44.97 59.24,45.24 59.54,45.24 59.77,45.47 59.77,47.2 60.83,48.26 60.83,51.85 62.09,53.11 63.54,53.11 64.41,52.25 64.41,51.7 65.71,50.39 66.84,50.39 67.5,49.73 68.27,49.73 69.94,48.05 70.7,48.05 71.29,47.46 71.29,46.16 73.43,44.02 74.3,44.02 74.74,43.57 74.74,39.03 75.41,38.36 75.41,34.93 76.4,33.94 76.4,29.16 77.58,27.97 77.9,27.97 v1(78.02,27.85)
  BOTTOM w0.114: v1(55.38,44.83) 54.98,45.23 52.8,45.23
  BOTTOM w0.147: v1(78.02,27.85) 78.46,27.42 81.35,27.42 81.71,27.77 93.21,27.77 93.67,27.32 106.96,27.32 106.97,27.31 R435.2 ; 52.8,45.23 52.72,45.23 52.34,45.6 52.34,46.9 TP56.1
SOC_BOOTMODE0: length 84.1
  L08_SIG2 w0.091: v1(67.81,85.98) 67.2,85.98 65.73,84.51 65.73,80.97 66.55,80.15 66.55,77.48 65.32,76.26 65.32,64.54 63.49,62.7 61.11,62.7 60.63,63.19 59.28,63.19 56.78,60.68 53.44,60.68 50.33,63.79 49.23,63.79 49.04,63.6 43.02,63.6 42.86,63.44 41.53,62.11 41.53,58.49 43.36,56.66 43.36,55.67 43.81,55.21 43.81,51.76 42.3,50.25 42.3,48.5 44.22,46.58 45.18,46.58 46.06,45.7 v1(46.06,44.57)
  BOTTOM w0.147: U48.15 67.49,86.3 v1(67.81,85.98) ; v1(46.06,44.57) 46.06,43.67 46.79,42.94 46.79,41.84 47.21,41.42 47.21,40.53 45.65,38.96 45.65,36.77 46.29,36.13 R119.2
SOC_BOOTMODE1: length 83.2
  L08_SIG2 w0.091: v1(67.81,87.02) 65.52,84.73 65.52,80.91 65.53,80.91 65.54,80.9 65.54,80.89 66.35,80.08 66.35,77.57 65.02,76.25 65.02,64.61 63.38,62.97 61.22,62.97 60.74,63.46 59.17,63.46 56.67,60.95 53.56,60.95 50.42,64.09 49.03,64.09 48.82,63.88 42.9,63.88 41.25,62.23 41.25,58.37 43.1,56.53 43.1,55.58 43.62,55.07 43.62,51.96 42.03,50.36 42.03,48.45 44.11,46.37 45.01,46.37 45.37,46 v1(45.37,45.26)
  BOTTOM w0.147: R122.2 46.82,39.72 47.54,40.44 47.54,41.61 47.2,41.95 47.2,43.16 46.57,43.78 46.57,44.73 46.04,45.26 v1(45.37,45.26) ; U48.14 67.49,86.7 v1(67.81,87.02)
SOC_BOOTMODE2: length 48
  TOP w0.147: R150.2 60.54,52.74 v1(60.54,53.61)
  L03_SIG1 w0.091: v1(60.54,53.61) 59.24,54.91 59.24,57.73 58.58,58.39 58.58,64.92 60.86,67.2 60.86,69.82 60.39,70.29 59.11,70.29 58.34,71.07 58.34,78.73 60.33,80.72 60.33,82.43 61.85,83.95 61.85,88.58 v1(62.86,89.59)
  BOTTOM w0.147: v1(62.86,89.59) 65.37,89.59 66.75,88.2 U48.13
SOC_BOOTMODE3: length 50
  L03_SIG1 w0.091: v1(61.59,89.59) 61.59,84.06 60.07,82.54 60.07,80.83 58.06,78.83 58.06,70.97 59,70.03 60.28,70.03 60.59,69.73 60.59,67.24 58.34,64.99 58.34,58.26 58.8,57.8 58.8,54.18 v1(59.37,53.61)
  BOTTOM w0.147: v1(59.37,53.61) 60.72,52.27 60.72,51.64 R151.2 ; U48.12 66.15,87.88 65.04,89 62.18,89 v1(61.59,89.59)
SOC_CLK_IN: length 1.4
  TOP w0.147: U43.4 R176.1
SOC_CLK_XTAL_IN: length 4.3
  TOP w0.147: R178.1 50.01,31.08 49.75,30.82 C184.1 47.39,30.82 47.22,30.99 Y1.1
SOC_CLK_XTAL_OUT: length 5.8
  TOP w0.147: Y1.3 46.02,34.28 46.15,34.4 47.74,34.4 48.25,33.89 C185.1 49.59,33.89 49.94,33.54 R179.1
SOC_I2C0_SCL: length 35.6
  TOP w0.147: R135.1 v1(62.62,51.73)
  BOTTOM w0.147: v1(62.62,51.73) 61.31,53.04 61.31,53.74 60.22,54.84 52.55,54.84 47.97,59.41 47.97,65.9 47.34,66.54 46.13,66.54 45.18,67.49 45.18,69.85 45.6,70.26 U26.4 48.48,70.26 R159.2
SOC_I2C0_SDA: length 30.8
  BOTTOM w0.147: R136.1 63.91,52.53 61.07,55.37 52.71,55.37 48.43,59.65 48.43,62.86 49.18,63.61 R158.2 U26.7
SOC_I2C2_SCL: length 119.4
  TOP w0.147: U46.3 v1(49.14,77.46) ; v1(66.54,76.31) 66.09,76.31 65.93,76.47 58.5,76.47 56.96,74.93 v1(56.96,74.37) ; U1.C7 v1(57.78,45.63) ; R156.2 v1(54.41,49.14)
  L03_SIG1 w0.091: v1(56.96,74.37) 56.44,73.86 56.44,73.61 55.27,72.44 52.23,72.44 50.46,70.67 50.46,65.08 49.52,64.14 49.52,62.45 49.97,62 v1(49.97,61.46) 49.97,57.58 54.76,52.79 54.76,49.49 v1(54.41,49.14)
  L08_SIG2 w0.091: v1(89.75,61.46) 89.75,60.48 85.91,56.63 81.44,56.63 80.23,55.43 79.08,55.43 78.3,54.65 71.79,54.65 70.45,55.98 69.42,55.98 69,56.41 67.6,56.41 66.85,57.16 66.85,68.65 67.03,68.82 67.03,75.83 v1(66.54,76.31) ; v1(49.14,77.46) 49.93,77.46 52.54,74.86 56.47,74.86 v1(56.96,74.37) ; v1(54.41,49.14) 54.74,49.14 55.52,48.35 55.82,48.35 56.59,47.58 56.59,46.26 56.81,46.04 57.37,46.04 v1(57.78,45.63)
  BOTTOM w0.147: U59.15 v1(66.54,76.31) ; v1(89.75,61.46) 89.75,60.55 89.09,59.89 U13.5 89.09,58.75 89.44,58.4 89.77,58.4 90.99,59.62 U12.5 ; U60.29 56.46,73.87 v1(56.96,74.37) ; U27.8 v1(49.97,61.46)
SOC_I2C2_SDA: length 117.3
  TOP w0.147: U46.2 v1(49.14,76.19) ; v1(68.07,76.31) 67.61,76.77 58.12,76.77 56.47,75.12 56.47,73.93 v1(56.96,73.44) ; R157.2 55.55,49.31 v1(55.73,49.14) ; U1.B7 v1(57.78,46.43)
  L03_SIG1 w0.091: v1(56.96,73.44) 55.6,72.09 52.4,72.09 50.73,70.42 50.73,64.75 49.97,63.99 v1(49.97,62.73) 50.55,62.14 50.55,57.72 54.94,53.33 54.94,49.92 v1(55.73,49.14)
  L08_SIG2 w0.091: v1(49.14,76.19) 50.71,76.19 52.38,74.52 55.88,74.52 v1(56.96,73.44) ; v1(57.78,46.43) 57.78,46.68 58.17,47.07 58.17,47.39 57.29,48.27 56.88,48.27 56.01,49.14 v1(55.73,49.14) ; v1(68.07,76.31) 67.56,75.8 67.56,68.36 67.36,68.16 67.36,57.97 67.67,57.66 69.8,57.66 70.79,56.67 70.79,56.19 71.2,55.78 71.49,55.78 72.04,56.33 77.33,56.33 78.93,57.93 85.66,57.93 87.74,60 87.74,60.94 v1(87.26,61.42)
  BOTTOM w0.147: v1(87.26,61.42) 87.87,60.81 88.37,60.81 88.59,60.58 U13.4 88.59,58.45 89.02,58.03 89.87,58.03 90.96,59.12 U12.4 ; U59.2 v1(68.07,76.31) ; U60.30 v1(56.96,73.44) ; U27.7 v1(49.97,62.73)
SOC_INTN: length 40.2
  TOP w0.147: v1(48.64,64.31) 47.99,64.96 U20.2
  L03_SIG1 w0.091: v1(52.06,95.24) 50.19,95.24 48.67,93.72 48.67,92.13 52.04,88.76 52.04,86.61 49.92,84.49 49.92,82.07 48.53,80.68 48.53,64.79 48.64,64.69 v1(48.64,64.31)
  BOTTOM w0.147: U76.5 v1(52.06,95.24)
SOC_MMC0_CLK: length 13.6
  TOP w0.147: U1.B6 v1(56.98,46.43) ; RA2.5 50.92,50.22 50.92,50.45 v1(51.03,50.55) 50.92,50.66 TP49.1
  L08_SIG2 w0.091: v1(56.98,46.43) 57.37,46.82 57.37,47.39 56.13,48.63 55.63,48.63 54.44,49.82 54.33,49.82 54.17,49.66 54.05,49.66 53.97,49.74 53.97,49.85 54.13,50.01 54.13,50.13 54.05,50.21 53.94,50.21 53.78,50.05 53.66,50.05 53.58,50.13 53.58,50.24 53.75,50.4 53.75,50.52 53.23,51.03 52.21,51.03 51.73,50.55 v1(51.03,50.55)
  BOTTOM w0.147: v1(51.03,50.55) 50.92,50.66 50.92,50.77 RA3.5
SOC_MMC0_CMD: length 12.8
  TOP w0.147: v1(46.6,50.53) 46.35,50.28 RA4.6 ; U1.A4 v1(55.38,47.23)
  L08_SIG2 w0.091: v1(55.38,47.23) 55.38,47.33 54.58,48.13 52.21,48.13 51.39,48.96 51.12,48.96 49.73,50.35 49.73,50.55 49.32,50.96 47.03,50.96 v1(46.6,50.53)
  BOTTOM w0.147: RA5.6 46.3,50.84 v1(46.6,50.53)
SOC_MMC0_DAT0: length 12.5
  TOP w0.147: v1(50.16,50.53) 49.9,50.28 RA2.6 ; U1.B5 v1(56.18,46.43)
  L08_SIG2 w0.091: v1(50.16,50.53) 50.16,50.43 50.33,50.26 50.89,49.7 51,49.7 51.05,49.76 51.17,49.76 51.25,49.68 51.25,49.56 51.19,49.51 51.19,49.4 51.34,49.25 51.56,49.25 51.76,49.45 51.87,49.45 51.95,49.37 51.95,49.26 51.81,49.11 51.81,49 51.9,48.9 52.09,48.9 52.5,49.31 53.24,49.31 53.46,49.08 53.46,48.89 53.37,48.79 53.18,48.79 53.09,48.7 53.09,48.51 53.18,48.42 54.68,48.42 55.37,47.73 55.52,47.73 55.79,47.46 55.79,46.82 v1(56.18,46.43)
  BOTTOM w0.147: RA3.6 49.85,50.84 v1(50.16,50.53)
SOC_MMC0_DAT1: length 12.8
  TOP w0.147: U1.B4 v1(55.38,46.43) ; 49.4,49.84 49.4,50.28 v1(49.14,50.53)
  L08_SIG2 w0.091: v1(49.14,50.53) 49.14,50.16 49.22,50.08 49.56,50.08 49.64,50 49.64,49.89 49.56,49.81 49.22,49.81 49.14,49.73 49.14,49.44 49.28,49.31 49.67,49.31 49.75,49.23 49.75,48.85 49.92,48.69 50.07,48.69 50.15,48.77 50.15,49.23 50.23,49.31 50.37,49.31 50.99,48.68 51.25,48.68 52.07,47.86 54.07,47.86 54.31,47.62 54.74,47.62 54.99,47.37 54.99,46.83 v1(55.38,46.43)
  BOTTOM w0.147: v1(49.14,50.53) 49.35,50.74 RA3.7
