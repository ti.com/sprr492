# Allegro board PROC159A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
XDS_GND on L08_SIG2: 10.02,77.85 10.02,108.19 40.64,108.19 40.64,97.02 41.02,96.63 44.32,96.63 44.57,96.38 44.57,74.41 38.86,74.41 35.49,77.77 10.09,77.77 ; 6 cut-outs
XDS_SHIELD on TOP, L02_GND1, L03_SIG1, L04_GND2, L05_PWR1, L06_PWR2, L07_GND3, L08_SIG2, L09_GND4: 9.27,99.43 9.27,88.63 13.58,88.63 13.58,92.82 11.68,92.82 11.68,97.27 13.71,97.27 13.71,99.43
XDS_SHIELD on BOTTOM: 9.27,99.43 9.27,88.63 13.58,88.63 13.58,92.82 11.68,92.82 11.68,97.27 13.71,97.27 13.71,99.43 ; 1 cut-out
N32995608 on BOTTOM: 96.75,87.07 96.75,80.34 99.32,80.34 99.32,86.56 101.66,86.56 101.66,87.07
N34755833 on TOP: 98.55,36.32 98.55,38.09 99.31,38.09 99.31,36.45 99.56,36.19 99.56,35.94 99.31,35.69 98.67,35.69 98.42,35.94 98.42,36.19
N34755833 on BOTTOM: 91.56,40.75 91.56,39.1 94.61,39.1 96.89,36.82 97.66,36.82 98.68,35.8 99.82,35.8 99.82,37.71 98.93,38.6 98.93,40.75
N34755845 on TOP: 98.55,45.96 98.55,44.31 99.31,44.31 99.31,45.83 99.56,46.09 99.56,46.34 99.31,46.6 98.67,46.6 98.42,46.34 98.42,46.09
N34755845 on BOTTOM: 94.74,45.83 94.74,41.27 98.84,41.27 98.84,43.21 100.07,44.44 100.07,46.72 98.29,46.72 98.29,45.96 98.17,45.83
N34780660 on BOTTOM: 99.54,65.82 99.54,61.5 101.57,61.5 101.57,65.82
N35053522 on TOP: 81.3,15.79 86.1,15.79 86.1,18.66 87.07,19.62 87.07,25.6 82.71,25.6 81.3,24.19
N35053536 on TOP: 75.74,23.73 75.74,21.78 76.45,21.07 78.48,21.07 79.58,22.17 80.89,22.17 80.89,23.99 79.24,23.99 79.24,23.99 75.99,23.99

Small or netless copper shapes (teardrops, artwork): 842 on TOP, 872 on BOTTOM, 440 on L03_SIG1, 2 on L05_PWR1, 1 on L06_PWR2, 467 on L08_SIG2

## Text on the board
Ref Des/Assembly Bottom: PROC159A ASSEMBLY BOTTOM
Ref Des/Silkscreen Bottom: B | C | A | FOR EVALUATION ONLY; | NOT FCC APPROVED FOR RESALE | ASSY
User.Comments: CR_1_2 | CR_1_1 | BOARD NAME: | AM263P CC | REV: A | DATE: 08/05/24 | DESCRIPTION: | SHEET | OF | 17 | PROC159A | SCALE: 1 | TEXAS INSTRUMENTS
Ref Des/Assembly Top: PROC159A ASSEMBLY TOP
Ref Des/Silkscreen Top: ETHERNET | CONN_0 | OPN# | SL# | PCB#: PROC159A
PAGE_OUTLINE: LAYOUT BY | REVIEWED BY | APPROVED BY | SIGNATURES | KK/ZA | AMB | ZA | DATE | 080524 | SCALE: | SIZE | D | NONE | TEXAS INSTRUMENTS | SHEET 1 OF 17 | PROC159A | Rev | A
DISPLAY_TOP: 19. | 18. | 16. | 17. | ALL BOARD OUTLINE INNER ANGLES THAT ARE NOT EXPLICITY DIMENTIONED SHALL BE WITH TOOL PATH 1.0MM DIA OR SMALLER. | EDGE FINGERS SHALL HAVE HARD GOLD FINISH AS PER IPC6012. | ENSURE UL REGISTERED E-FILE NUMBER SHALL BE PRINTED ON THE PCB SILKSCREEN. | VIA ON PAD SHALL BE RESIN FILLED AND CAP-PLATED.
User.16: TITLE: | MISTRAL | AM62A AUTOMOTIVE RGMII | R | #60, ADARSH REGENT, 100'FT RING ROAD, | MISTRAL SOLUTIONS PVT.LTD., | DOMLUR EXTENSION, BANGALORE-560 071 | TOP ASSEMBLY OF PROC151E1 | 8 | A | 5 | 4 | 28 | SK-ETH-AUTO-DCO2 | PROC151E1 | 9 | 19 | 3 | 2 | SHEET    OF 13 | 50 | 49 | BOTTOM ASSEMBLY OF PROC151E1 | DATE: | 20AUG22 | REV | E1 | SCALE: 1
User.17: 8 | 5 | 4 | 28 | 9 | 19 | 3 | 2 | 50 | 49 | A | SK-ETH-AUTO-DCO2 | PROC151E1 | R | TOP ASSEMBLY OF PROC151E1 | BOTTOM ASSEMBLY OF PROC151E1 | TITLE: | AM62A AUTOMOTIVE RGMII | #60, ADARSH REGENT, 100'FT RING ROAD, | MISTRAL SOLUTIONS PVT.LTD., | DOMLUR EXTENSION, BANGALORE-560 071 | SHEET    OF 13 | DATE: | 20AUG22 | REV | E1 | SCALE: 1 | MISTRAL
User.45: 03 | 04 | 05 | 06 | STRIPLINE | MICROSTRIP | EDGE COUPLED STRIPLINE | EDGE COUPLED MICROSTRIP | L3,L8 | L1,L10 | L8 | 3.6 | 5.8 | 4.2 | 3.7 | NA | 4.4 | 6 | FIGURE | 50 | 90 | SIZE | 8.0 | 36.0 | 40.0 | 44.0 | 66.0 | 32.0 | 108.0 | 126.0 | 62.0x24.0 | 76.0x28.0 | 82.0x24.0 | L2/L4,L7/L9 | L2,L9 | L7/L9 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 2215 | 14 | 18 | 12 | 22 | 2 | 21 | 11 | 6 - Provide serial numbers to the assembled boards for identification. | 7 - The assembled board are wrapped in ESD Covers(individual) and packed securely before shipment. | ASSEMBLY NOTES:- | 1 - All MSL components should be baked as per JEDEC standard. | 2 - PCB should be baked at 120 degree for 8 hours. | 3 - Board assembly must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified. | 4 - These assemblies are ESD sensitive, ESD precautions shall be observed. | 5 - These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable. | PROC101 E2 ASSEMBLY TOP | PROC101 E2 ASSEMBLY BOTTOM
