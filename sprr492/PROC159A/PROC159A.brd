# Allegro board PROC159A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N34779936: length 1.4
  TOP w0.147: Q7.1 111.63,55.91 111.88,55.66 R222.2
N34780102: length 8
  TOP w0.147: R207.1 R211.1 72.08,37.22 71.58,36.72 70.12,36.72 68.07,38.77 67.04,38.77 U1.L18
N34780104: length 8.9
  TOP w0.147: U1.L17 66.58,38.43 67.99,38.43 70,36.42 71.6,36.42 72.08,35.95 R209.1 R208.1
N34780660: length 2.3
  BOTTOM w0.381: J7.2 100.38,63.39 100.44,63.32 FL3.2
N34780919: length 1.4
  BOTTOM w0.147: Q8.1 112.93,58.5 R223.2
N34780978: length 2.9
  BOTTOM w0.147: U35.29 84.98,67.84 84.26,67.12 84.26,66.78 83.67,66.19 R210.2
N34780980: length 1.9
  BOTTOM w0.147: R213.1 91.31,73.24 90.92,72.85 U35.46
N34780998: length 2.3
  BOTTOM w0.147: U35.32 84.25,69.34 83.67,69.93 R212.2
N34781014: length 1.4
  BOTTOM w0.147: Q6.1 R221.2
N34781978: length 0.9
  TOP w0.147: U15.3 R81.2
N34798910: length 1.2
  BOTTOM w0.147: C99.1 89.41,80.71 U16.4
N34800889: length 3.8
  TOP w0.147: R94.2 50.2,39.38 51.55,38.03 U1.M1
N34800895: length 5.1
  TOP w0.147: U1.L2 53.78,38.43 52.19,38.43 50.2,40.42 R96.2
N34801624: length 8.6
  TOP w0.147: U1.K2 v1(53.78,39.23)
  BOTTOM w0.147: R191.1 50.78,42.62 50.92,42.48 50.92,41.99 51.6,41.32 51.6,40.69 53.06,39.23 v1(53.78,39.23)
N34801627: length 8.9
  TOP w0.147: U1.K4 v1(55.38,39.23)
  BOTTOM w0.147: v1(55.38,39.23) 54.55,40.06 53.23,40.06 52.33,40.96 52.33,41.8 51.65,42.47 51.65,43.52 50.81,44.35 R192.1
N34801685: length 5.2
  TOP w0.147: R194.1 50.76,43.99 51.97,42.78 51.97,41.84 U1.J1
N34801688: length 16.4
  TOP w0.147: v1(55.72,53.09) 56.08,52.73 R195.1 ; U1.J4 v1(55.38,40.83)
  L03_SIG1 w0.091: v1(55.38,40.83) 55.78,41.23 57.17,41.23 57.38,41.43 57.38,48.37 57.19,48.56 57.19,49.5 56.07,50.61 56.07,52.73 v1(55.72,53.09)
N34801691: length 7.3
  TOP w0.147: U1.K3 v1(54.58,39.23)
  BOTTOM w0.147: v1(54.58,39.23) 54.13,39.69 53.1,39.69 51.89,40.9 51.89,41.54 51.3,42.13 51.3,42.79 50.89,43.21 R196.1
N34820051: length 3.9
  BOTTOM w0.147: J11.26 57.74,101.21 57.48,100.95 56.13,100.95 55.88,100.7 R295.2
N34820524: length 2.3
  TOP w0.147: Q5.2 92.96,41.2 93.09,41.33 R200.2
N34820530: length 2
  TOP w0.147: LD8.2 Q5.3
N34828765: length 1.3
  TOP w0.147: R72.2 LD5.2
N34828799: length 2.2
  TOP w0.147: R73.2 51.07,75.56 51.62,75.01 LD4.2
N34828801: length 1.5
  TOP w0.147: LD4.1 Q2.3
N34828819: length 1.5
  TOP w0.147: R76.1 55.22,79.09 54.96,78.83 Q2.1
N34830317: length 3.2
  BOTTOM w0.147: U12.10 97.72,57.62 C92.1 98.19,57.52 98.93,57.52 99.23,57.22 R69.1
N34830329: length 5.1
  BOTTOM w0.147: R71.1 99.27,58.24 98.93,57.9 98.43,57.9 C92.2 ; U12.8 97.7,58.62 C92.2 ; C92.2 97.81,58.12 U12.9
N34830425: length 3.5
  BOTTOM w0.147: U13.10 87.09,53.58 87.06,53.55 C91.1 87.37,52.65 87.37,52.18 R68.1
N34830437: length 5.6
  BOTTOM w0.147: R70.1 87.75,52.09 87.75,52.57 88.04,52.86 C91.2 ; U13.9 87.59,53.4 C91.2 ; C91.2 88.04,53.55 88.09,53.6 U13.8
N34869480: length 3.3
  TOP w0.147: U78.6 82.19,35.05 82.51,35.37 R431.2 R432.2
N34869775: length 1.3
  BOTTOM w0.147: C57.1 R29.2
N35052540: length 1.2
  BOTTOM w0.147: U17.5 103.31,13.13 R7.1
N35052638: length 1.7
  TOP w0.147: U4.10 95.02,15.27 94.85,15.1 R18.1
N35052879: length 2.3
  TOP w0.147: C9.1 99.43,18.92 99.8,18.55 U3.6
N35052899: length 2.1
  BOTTOM w0.147: R6.2 103.63,11.6 103.31,11.93 102.97,11.93 102.55,12.35 U17.6
N35052954: length 1.8
  BOTTOM w0.147: U17.3 102.7,13.93 103,14.22 103,14.63 103.54,15.18 R2.2
N35052969: length 2.8
  BOTTOM w0.147: U17.9 101.05,12.39 100.71,12.05 99.9,12.05 TP1.1
N35053013: length 1.9
  BOTTOM w0.147: R8.1 100,13.53 U17.11
N35053423: length 1.7
  TOP w0.147: U4.11 95.52,15.38 95.8,15.1 C16.1
N35053536: length 10.2
  BOTTOM w0.147: v1(78.3,21.45) 76.12,19.27 76.12,15.35 76.84,14.63 C24.1 R22.2
N35053695: length 2
  BOTTOM w0.147: R23.1 86.5,16.58 86.18,16.26 U5.7
N35053732: length 1.3
  BOTTOM w0.147: R24.1 C23.2
N35056553: length 1.7
  TOP w0.147: R1.2 101.86,14.53 102.2,14.86 LD1.2
N35059517: length 4.7
  TOP w0.147: U1.B10 v1(60.98,46.43)
  BOTTOM w0.147: v1(60.98,46.43) 60.98,47.06 62.69,48.77 R141.2
N35065419: length 12.4
  TOP w0.147: U7.12 103.19,36.31 v1(103.42,36.08)
  L08_SIG2 w0.091: v1(103.42,36.08) 102.79,35.46 101.82,35.46 100.67,36.61 95.22,36.61 94.77,37.06 v1(94.4,37.06)
  BOTTOM w0.147: R42.1 v1(94.4,37.06)
N35071225: length 10.1
  TOP w0.147: U7.18 106.19,36.36 106.19,36.36 106.19,35.73 106.29,35.63 106.29,35.62 v1(106.62,35.3)
  L03_SIG1 w0.091: v1(108.02,29.1) 107.21,29.91 107.21,34.7 v1(106.62,35.3)
  BOTTOM w0.147: v1(108.02,29.1) 107.57,28.65 R435.1
N35139843: length 12.4
  TOP w0.147: U7.34 v1(104.69,46.09)
  L03_SIG1 w0.091: v1(104.69,46.09) 105.21,46.6 106.39,46.6 108.34,48.55 108.34,50.54 v1(111.04,53.24)
  BOTTOM w0.147: v1(111.04,53.24) 110.92,53.12 R142.1
N35230144: length 2.2
  TOP w0.147: U18.5 30.35,56.38 29.93,56.79 R439.1
N35230147: length 1.6
  TOP w0.147: R440.1 40.11,53.84 U18.2
N35230153: length 1.6
  TOP w0.147: U18.7 R442.1
N35244293: length 3.7
  TOP w0.147: R452.1 36.1,43.66 35.64,44.11 33.3,44.11 U19.D2
N35244332: length 3.2
  TOP w0.147: R453.1 28.58,42.3 28.81,42.08 30.26,42.08 U19.C4
N35244360: length 3.3
  TOP w0.147: U19.D4 30.26,44.24 28.59,44.24 28.03,44.8 R454.1
N35244387: length 2
  TOP w0.147: R455.1 28.48,43.57 28.71,43.8 29.25,43.8 29.39,43.66 U19.D5
N35244414: length 3.2
  TOP w0.147: R456.1 31.33,46.63 31.85,46.11 U19.E3
N35244441: length 3.4
  TOP w0.147: U19.E2 33.85,45.66 R457.1
N35244468: length 2.6
  TOP w0.147: U19.E1 34.38,44.66 35.13,45.41 R458.1
N35248046: length 4.3
  TOP w0.147: U19.D3 32.43,44.24 32.43,44.83 32.6,45.01 R451.1
N35252647: length 1.6
  TOP w0.147: U18.3 40.11,55.11 R441.1
N35271296: length 2
  TOP w0.147: TP78.1 17.96,25.36 18.42,24.91 U29.8
N35329968: length 5.4
  TOP w0.147: U1.L3 v1(54.58,38.43)
  BOTTOM w0.147: v1(54.58,38.43) 52.77,38.43 51.52,39.69 R117.2
N35329989: length 5.3
  TOP w0.147: U1.M3 v1(54.58,37.63)
  BOTTOM w0.147: v1(54.58,37.63) 54.11,38.1 52.52,38.1 52.07,38.54 R118.2
N35342843: length 1.5
  TOP w0.147: U57.15 44.2,105.26 R371.1
N35343433: length 1.6
  TOP w0.147: U57.14 44.07,103.99 R372.1
N35343436: length 1.5
  TOP w0.147: U57.13 44.2,102.72 R373.1
N35343439: length 1.6
  TOP w0.147: U57.12 44.07,101.45 R374.1
N35343442: length 1.5
  TOP w0.147: U57.11 44.2,100.18 R375.1
N35343445: length 1.5
  TOP w0.147: R376.1 44.2,98.91 U57.10
N35345342: length 1.8
  BOTTOM w0.147: U58.7 18.51,73.06 18.51,73.05 R378.1
N35373997: length 4.6
  TOP w0.147: R315.1 41.28,79.36 41.91,78.73 U46.5 v1(43.94,78.73)
  BOTTOM w0.147: R314.1 44.18,78.48 v1(43.94,78.73)
N35375175: length 2.1
  BOTTOM w0.147: R34.1 J20.1
N35376496: length 3.2
  BOTTOM w0.147: J21.1 17.71,17.22 17.69,17.25 R175.2 R31.1
N35387120: length 3.5
  TOP w0.147: U29.7 22.59,24.91 22.9,25.22 22.9,26.45 23.28,26.83 R116.1
N35387809: length 4.6
  TOP w0.147: R1678.1 43.93,40.95 v1(44.79,41.82)
  BOTTOM w0.147: U80.8 43.79,40.82 v1(44.79,41.82)
N35395797: length 2.2
  TOP w0.147: U20.15 52.77,64.96 53.35,64.38 R461.1
N35537520: length 11.8
  TOP w0.147: v1(90.8,35.17) 91.18,34.79 94.86,34.79 95.27,34.38 R20.1 95.28,32.65 95.69,32.24 95.69,32.22 95.72,32.19 Q13.4
  BOTTOM w0.147: R469.1 89.85,34.21 v1(90.8,35.17)
N35538921: length 2.2
  BOTTOM w0.147: Q12.3 88.42,33.07 88.87,32.62 R469.2
N35654609: length 1.7
  TOP w0.147: Q20.2 R3832.2
N35654631: length 1.7
  TOP w0.147: LD19.2 Q20.3
N35656175: length 1.3
  TOP w0.147: LD2.2 R47.2
N35656498: length 1.3
  TOP w0.381: R3833.2 LD20.2
N35656998: length 1.1
  TOP w0.147: R3834.2 LD21.2
N35657235: length 1.3
  TOP w0.381: R3835.2 LD22.2
N35672996: length 3.3
  TOP w0.147: SW15.2 62.89,55.21 62.51,55.59 R3842.2
N35712813: length 55.9
  TOP w0.147: R116.2 24.79,27.42 27.1,29.73 36.88,29.73 37.94,28.66 37.94,27.04 39.14,25.84 40.05,25.84 40.89,25.01 47.58,25.01 50.86,21.73 65.76,21.73 67.05,20.43 73.58,20.43 J22.2
N35805242: length 14.2
  TOP w0.147: v1(76.94,48.25) 76.94,46.83 75.55,45.44 70.26,45.44 67.99,43.17 67.32,43.17 U1.F18
  BOTTOM w0.147: v1(76.94,48.25) 77.2,48.5 R247.1
N35805430: length 8.2
  TOP w0.147: v1(72.71,48.51) 71.11,46.91 69.37,46.91 67.69,45.23 U1.C18
  BOTTOM w0.147: v1(72.71,48.51) 73.07,48.51 73.21,48.66 R255.1
N35805533: length 16.9
  TOP w0.147: R248.1 76.82,49.29 76.34,48.81 76.34,47.01 v1(75.59,46.26) ; U1.G16 v1(65.78,42.43)
  BOTTOM w0.114: 67.8,42.2 67.63,42.03 66.18,42.03 65.78,42.43 v1(65.78,42.43)
  BOTTOM w0.147: 67.8,42.2 68.66,43.06 68.66,44.82 69.92,46.08 74.96,46.08 75.14,46.26 v1(75.59,46.26)
N35805539: length 12.7
  TOP w0.147: U1.E17 66.58,44.03 67.97,44.03 69.97,46.03 73.99,46.03 74.75,46.79 74.75,47.85 75.64,48.73 R249.1
N35805550: length 12.3
  TOP w0.147: U1.E18 68.04,43.63 70.14,45.73 74.17,45.73 75.56,47.12 v1(75.56,47.99)
  BOTTOM w0.147: v1(75.56,47.99) 75.56,48.44 75.73,48.61 R250.1
N35805561: length 13.7
  TOP w0.147: U1.F16 v1(65.78,43.23) ; R251.1 74.42,48.31 73.93,47.82 v1(73.93,46.78)
  BOTTOM w0.114: 67.07,43.02 66.88,42.83 66.18,42.83 65.78,43.23 v1(65.78,43.23)
  BOTTOM w0.147: 67.07,43.02 67.95,43.9 67.95,44.71 69.73,46.49 73.05,46.49 73.34,46.78 v1(73.93,46.78)
N35805574: length 10.2
  TOP w0.147: U1.F15 v1(64.98,43.23)
  BOTTOM w0.114: 66.36,43.84 66.15,43.63 65.38,43.63 v1(64.98,43.23)
  BOTTOM w0.147: R252.1 70.85,47.2 70.49,46.84 69.36,46.84 66.36,43.84
N35805586: length 9.5
  TOP w0.147: v1(70.27,47.37) 71.03,47.37 71.98,48.31 R253.1 ; U1.E16 v1(65.78,44.03)
  BOTTOM w0.147: v1(70.27,47.37) 69.12,47.37 v1(65.78,44.03)
N35805597: length 9.8
  TOP w0.147: U1.D18 67.82,44.43 69.71,46.32 71.74,46.32 v1(73.93,48.51)
  BOTTOM w0.147: R254.1 74.43,48.66 74.29,48.51 v1(73.93,48.51)
N35805610: length 9.6
  TOP w0.147: U1.D17 66.57,44.82 67.79,44.82 69.59,46.62 71.5,46.62 73.2,48.31 R256.1
N35805636: length 5.7
  TOP w0.147: v1(70.27,48.51) 69.81,48.51 69.57,48.27 69.57,48.14 67.46,46.03 U1.B18
  BOTTOM w0.147: R257.1 69.63,48.68 69.8,48.51 v1(70.27,48.51)
N35805639: length 5.1
  TOP w0.147: R258.1 69.54,48.68 67.28,46.42 66.57,46.42 U1.B17
N35805644: length 6.1
  TOP w0.147: U1.D16 v1(65.78,44.83)
  BOTTOM w0.147: v1(65.78,44.83) 68.41,47.46 R259.1
N35805649: length 6.9
  TOP w0.147: R260.1 70.76,48.24 70.41,47.89 69.8,47.89 67.53,45.62 66.57,45.62 U1.C17
N35805656: length 3.8
  TOP w0.147: R261.1 67.57,49.29 66.52,48.24 66.52,47.17 U1.A17
N35805662: length 4.8
  TOP w0.147: U1.C16 v1(65.78,45.63)
  BOTTOM w0.147: R262.1 67.19,47.96 66.35,47.12 66.35,46.2 v1(65.78,45.63)
N35805667: length 5.5
  TOP w0.147: U1.C15 v1(64.98,45.63) ; v1(66.22,48.87) 66.43,49.08 R1652.1
  BOTTOM w0.114: 65.38,47.56 65.38,46.03 v1(64.98,45.63)
  BOTTOM w0.147: 65.38,47.56 65.38,48.03 v1(66.22,48.87)
N35805672: length 6.1
  TOP w0.147: R1653.1 v1(65.2,48.85) ; U1.D15 v1(64.98,44.83)
  BOTTOM w0.114: v1(64.98,44.83) 64.58,45.23 64.58,47.56
  BOTTOM w0.147: 64.58,47.56 64.58,48.24 v1(65.2,48.85)
N35820709: length 1.6
  TOP w0.147: SW14.2 R3858.2
N35821153: length 4.8
  BOTTOM w0.147: U88.19 83.59,107.33 83.93,107.67 86.37,107.67 86.59,107.46 R1399.2
N35824901: length 1.9
  BOTTOM w0.147: R475.2 70.37,29.83 70.82,29.38 U81.9
N35842882: length 1.6
  BOTTOM w0.147: R3870.2 U90.9
N35844058: length 1.6
  TOP w0.147: SW16.2 R3872.2

## Copper pours and planes (outline as drawn)
DGND on L03_SIG1 (solid shape): 88.12,24 88.19,24.09 88.3,24.07 91.78,20.58 91.78,20.2 91.4,20.2 88.12,23.47
DGND on L03_SIG1 (solid shape): 37.1,16.25 37.21,16.27 37.27,16.18 37.27,11.13 37.09,10.95 36.98,10.93 36.92,11.02 36.92,16.07
DGND on L03_SIG1 (solid shape): 61.27,22.6 61.38,22.62 61.44,22.53 61.44,20.22 61.1,19.89 60.99,19.86 60.93,19.96 60.93,22.27
DGND on L03_SIG1 (solid shape): 88.67,24.93 88.7,24.97 88.76,24.96 93.4,20.32 93.4,19.64 93.34,19.54 93.23,19.57 92.56,20.24 92.56,20.93 88.67,24.81
DGND on L03_SIG1 (solid shape): 96.15,26.73 96.21,26.83 96.32,26.8 96.66,26.46 96.66,22.95 96.59,22.86 96.48,22.88 96.15,23.22
DGND on L03_SIG1 (solid shape): 97.35,15.57 97.41,15.58 97.44,15.54 97.44,14.55 98.19,13.8 98.19,13.49 98.13,13.39 98.02,13.41 97.29,14.14 97.29,15.51
DGND on L03_SIG1 (solid shape): 90.06,13.3 90.13,13.39 90.24,13.37 90.61,12.99 90.61,12.55 90.3,12.23 90.3,9.93 90.23,9.83 90.12,9.85 90.06,9.92
DGND on L03_SIG1 (solid shape): 96.97,13.52 97.03,13.61 97.14,13.59 97.92,12.81 97.92,9.12 98.26,8.78 98.26,8.56 98.19,8.47 98.08,8.49 97.59,8.98 97.59,12.41 96.97,13.04
DGND on L03_SIG1 (solid shape): 59.33,9.52 59.44,9.54 59.5,9.45 59.5,9.01 57.14,6.65 57.04,6.62 56.97,6.7 56.92,6.81 56.85,6.9 56.85,7.04
DGND on L03_SIG1 (solid shape): 92.18,14.39 92.24,14.48 92.35,14.46 93.01,13.8 93.01,10.69 92.48,10.16 92.46,10.16 92.37,10.15 92.29,10.12 92.19,10.13 92.14,10.21 92.14,11.44 92.79,12.09 92.79,13.26 92.18,13.88
DGND on L03_SIG1 (solid shape): 55.73,18.83 55.84,18.86 55.9,18.76 55.9,18.32 54.8,17.22 54.8,16.5 54.68,16.32 54.68,16.11 54.66,16.02 54.58,15.98 51.46,15.98 51.37,16.04 51.39,16.15 53.6,18.36 55.25,18.36
DGND on L03_SIG1 (solid shape): 47.51,26.84 47.62,26.86 47.69,26.77 47.69,24.93 47.64,24.85 47.54,24.84 47.17,24.82 47,24.49 47,24.47 46.65,24.12 46.65,22.47 43.27,19.1 43.16,19.07 43.1,19.17 43.1,22.43
DGND on L03_SIG1 (solid shape): 59.65,19.95 59.65,19.01 57.67,17.03 57.66,17.02 57.63,17 57.6,17 57.57,17 57.54,17.01 57.52,17.03 57.51,17.06 57.5,17.09 57.5,17.1 57.5,18.86 57.94,19.3 58.74,19.3 58.74,19.24 58.76,19.19 58.78,19.14 58.8,19.09 58.84,19.04 58.88,19.01 58.92,18.97 58.97,18.95 59.03,18.93 59.08,18.92 59.14,18.92 59.19,18.92 59.25,18.94 59.3,18.96 59.34,18.99 59.39,19.02 59.42,19.07 59.45,19.11 59.48,19.16 59.49,19.22 59.5,19.27 59.5,19.33 59.49,19.38 59.48,19.44 59.45,19.49 59.42,19.53 59.39,19.57 59.34,19.61 59.3,19.64 59.25,19.66 59.19,19.67 59.14,19.68 59.08,19.68 59.03,19.67 58.97,19.65 58.92,19.62 58.88,19.59 58.84,19.55 58.8,19.51 58.78,19.46 58.76,19.41 58.74,19.35 58.74,19.3 57.94,19.3 59.12,20.48
DGND on L03_SIG1 (solid shape): 31.61,15.19 31.66,15.16 31.65,15.1 31.18,14.63 31.18,10.69 30.59,10.1 30.48,10.08 30.41,10.17 30.41,12.09 30.45,12.16 30.53,12.19 30.98,12.56 30.53,12.94 30.45,12.96 30.41,13.04 30.41,14.13 31.47,15.19
DGND on L03_SIG1 (solid shape): 28.43,8.76 28.6,8.64 28.81,8.63 28.89,8.62 28.93,8.54 28.93,7.03 28.89,6.95 28.79,6.94 28.43,6.91 28.26,6.58 28.26,6.56 28.17,6.48 28.12,6.47 28.09,6.51 28.09,6.91 27.42,7.58 27.42,7.6 27.38,7.78 27.26,7.92 27.22,7.99 27.25,8.07 27.94,8.76
DGND on L03_SIG1 (solid shape): 30.95,15.61 30.99,15.57 31.03,15.5 31,15.42 29.92,14.34 29.92,6.93 29.98,6.87 29.95,6.84 29.87,6.51 30.08,6.25 30.11,6.23 30.11,5.46 31.28,4.28 31.3,4.17 31.21,4.11 28.78,4.11 28.46,4.43 28.46,5.1 28.5,5.18 28.58,5.2 28.89,5.29 29.02,5.58 29.02,5.6 29.43,6.01 29.43,11.89 29.43,11.9 29.43,12.46 29.43,12.46 29.43,14.28 30.76,15.61
DGND on L03_SIG1 (solid shape): 78.98,24.14 79.04,24.23 79.15,24.21 79.72,23.65 79.72,21.92 79.68,21.84 79.59,21.82 79.12,21.45 79.59,21.08 79.68,21.06 79.72,20.98 79.72,19.86 79.15,19.29 79.04,19.27 78.98,19.37 78.98,22.33 78.72,22.59 78.98,22.85 78.98,23.15 78.96,23.24 78.91,23.32 78.72,23.51 78.98,23.77
DGND on L03_SIG1 (solid shape): 79.52,27.97 79.57,27.88 79.57,27.71 80.04,27.24 80.04,26.65 80.3,26.39 80.11,26.21 80.06,26.13 80.04,26.03 80.04,25.84 80.06,25.75 80.11,25.67 80.25,25.53 80.3,25.48 80.11,25.29 80.06,25.21 80.04,25.12 80.04,24.93 80.06,24.83 80.11,24.75 80.25,24.62 80.3,24.57 80.11,24.38 80.06,24.3 80.04,24.2 80.04,24.15 80.01,24.1 79.95,24.11 79.01,25.06 79.01,27.81 79.05,27.89 79.13,27.91 79.28,27.91 79.41,27.97
DGND on L03_SIG1 (solid shape): 33.17,6.68 33.28,6.7 33.34,6.61 33.34,5.79 33.62,5.51 33.62,4.91 33.58,4.83 33.5,4.81 33.31,4.79 33.15,4.68 32.51,4.68 32.35,4.52 31.75,4.52 30.9,5.37 30.88,5.46 30.94,5.53 31.01,5.57 31.07,5.63 31.4,5.63 31.47,5.6 31.5,5.51 31.95,5.07 32.2,5.65 32.17,5.68
DGND on L03_SIG1 (solid shape): 35.05,15.91 35.05,10.83 34.01,9.79 33.9,9.77 33.84,9.86 33.84,11.2 34.09,11.44 34.09,11.89 34.17,12.37 33.7,12.54 33.61,12.55 33.56,12.63 33.56,14.66 34.38,15.48 34.41,15.48 34.76,16.03 34.11,16.1 34.03,16.06 33.95,16.1 33.9,16.15 33.9,16.2 34.1,16.4 34.56,16.4
DGND on L03_SIG1 (solid shape): 22.3,16.18 22.38,16.13 22.39,16.03 22.35,15.79 22.48,15.57 22.48,14.67 22.44,14.63 22.36,14.6 22.29,14.65 21.61,14.59 22.06,14.08 22.15,14.06 22.19,13.98 22.19,11.06 20.34,9.21 20.34,4.85 20.31,4.8 20.25,4.81 20.16,4.91 20.16,9.33 21.19,10.36 21.19,11.49 21.04,11.63 21.02,11.74 21.09,11.81 21.39,12.25 20.95,12.55 20.86,12.58 20.83,12.65 20.83,15.4 20.87,15.49 20.96,15.5 21.3,15.56 21.46,15.87 21.46,15.89 21.74,16.18
DGND on L03_SIG1 (solid shape): 97.73,27.52 97.73,25.36 98.75,24.35 98.77,24.25 98.69,24.18 98.5,23.53 99.14,23.73 99.21,23.8 99.31,23.78 99.57,23.52 99.57,20.95 99.51,20.85 99.4,20.87 97.46,22.81 97.46,23.36 97.51,23.44 97.6,23.45 98.13,23.8 97.6,24.15 97.51,24.16 97.46,24.25 97.46,24.28 97.5,24.36 97.58,24.38 98.04,24.75 97.58,25.13 97.5,25.15 97.46,25.23 97.46,26.77 97.14,27.09 97.12,27.2 97.21,27.27 97.6,27.65
DGND on L08_SIG2 (solid shape): 103.34,26.96 102.56,26.18 102.45,26.16 102.39,26.26 102.39,29.07 102.9,29.59 103.34,29.59
DGND on L08_SIG2 (solid shape): 106.52,45.2 106.58,45.3 106.69,45.27 107.76,44.21 107.76,38.71 107.49,38.44 107.25,38.68 107.25,44.32 106.52,45.05
DGND on L08_SIG2 (solid shape): 35.13,17.94 35.17,17.89 33.82,16.54 31.38,16.54 31.28,16.6 31.3,16.71 31.65,17.06 34.15,17.06 35.07,17.97
DGND on L08_SIG2 (solid shape): 62.33,32.61 62.33,31.98 60.72,30.37 60.18,30.37 60.09,30.43 60.11,30.54 62.26,32.69
DGND on L08_SIG2 (solid shape): 23.88,15.72 23.88,14.6 24.46,14.03 24.46,13.18 24.4,13.09 24.29,13.11 23.72,13.68 23.72,15.37 23.74,15.39 23.74,15.57 23.81,15.65 23.85,15.75
DGND on L08_SIG2 (solid shape): 30.17,8.72 30.21,8.69 30.2,8.64 28.92,7.36 28.24,7.36 27.81,7.79 27.79,7.9 27.88,7.96 29.32,7.96 30.08,8.72
DGND on L08_SIG2 (solid shape): 35.24,15.73 35.35,15.75 35.41,15.66 35.41,14.68 34.79,14.06 33.81,14.06 32.14,12.38 32.01,12.38 31.96,12.41 31.97,12.47
DGND on L08_SIG2 (solid shape): 46.49,30.92 46.58,30.86 46.56,30.75 45.86,30.05 43.13,30.05 43.03,30.11 43.06,30.22 43.76,30.92
DGND on L08_SIG2 (solid shape): 47.87,19.07 47.97,19 47.95,18.89 47.45,18.39 43.49,18.39 43.39,18.45 43.42,18.57 43.92,19.07
DGND on L08_SIG2 (solid shape): 48.32,33.09 48.41,33.02 48.39,32.91 48.2,32.72 41.79,32.72 41.7,32.78 41.72,32.89 41.91,33.09
DGND on L08_SIG2 (solid shape): 98.9,11.66 98.9,11.17 98.84,11.07 98.73,11.09 97.05,12.77 97.03,12.88 97.12,12.94 97.62,12.94
DGND on L08_SIG2 (solid shape): 99.77,13.94 99.79,13.83 99.7,13.77 99.33,13.77 98.03,15.07 98.01,15.18 98.1,15.25 98.46,15.25
DGND on L08_SIG2 (solid shape): 104.34,30.01 104.45,30.03 104.51,29.94 104.51,27.69 104.01,27.19 103.9,27.16 103.84,27.26 103.84,29.5
DGND on L08_SIG2 (solid shape): 63.76,31.15 63.87,31.17 63.93,31.08 63.93,31.03 59.99,27.09 59.7,27.09 59.61,27.15 59.63,27.26 60.9,28.53 61.14,28.53
DGND on L08_SIG2 (solid shape): 14.69,32.54 14.8,32.56 14.87,32.47 14.87,28.19 14.07,27.39 14.07,23.3 14.04,23.25 13.98,23.26 13.96,23.28 13.96,26.89 13.06,27.78 13.06,31.48 13.59,32 14.16,32
DGND on L08_SIG2 (solid shape): 64.52,12.79 64.63,12.81 64.69,12.71 64.69,10.64 64.23,10.18 64.19,10.18 64.11,10.22 64.09,10.31 64.1,10.35 64.1,10.42 64.23,10.55 64.23,12.5
DGND on L08_SIG2 (solid shape): 66.47,28.71 66.51,28.63 66.51,27.56 65.68,26.74 65.61,26.73 65.56,26.73 65.47,26.74 65.44,26.82 65.44,27.86 66.3,28.73 66.39,28.73
DGND on L08_SIG2 (solid shape): 81.63,26.87 81.69,26.96 81.79,26.96 81.84,26.92 81.84,20.13 75.96,14.25 75.52,14.25 75.43,14.31 75.45,14.42 81.63,20.6
DGND on L08_SIG2 (solid shape): 57.03,29.32 57.03,29.3 57.04,29.24 57.05,29.18 57.03,29.09 56.95,29.05 56.78,29.05 56.61,28.88 55.04,28.88 54.95,28.94 54.97,29.05 55.42,29.5 56.85,29.5
DGND on L08_SIG2 (solid shape): 37.77,15.3 37.82,15.38 37.92,15.39 38.02,15.36 38.14,15.36 38.22,15.34 38.25,15.26 38.25,14.03 33.45,9.22 33.12,9.22 33.02,9.29 33.05,9.4 37.77,14.12
DGND on L08_SIG2 (solid shape): 54.95,32.97 55.03,32.94 55.05,32.86 55.05,32.79 55.07,32.73 55.05,32.64 54.97,32.6 54.12,32.6 53.49,31.96 49.58,31.96 49.49,32.03 49.51,32.14 50.04,32.67 53,32.67 53.31,32.97
DGND on L08_SIG2 (solid shape): 76.15,38.37 76.21,38.46 76.32,38.44 76.64,38.12 76.64,35.46 77.37,34.73 77.4,34.64 77.35,34.56 77.25,34.49 77.18,34.39 77.1,34.34 77.02,34.37 76.15,35.23
DGND on L08_SIG2 (solid shape): 40.38,44.7 41.99,44.7 42.19,44.89 42.3,44.91 42.36,44.82 42.36,42.6 41.97,42.2 39.93,42.2 39.53,42.61 39.53,44.62 39.65,44.83 39.62,45.08 39.62,45.18 39.71,45.23 39.85,45.23
DGND on L08_SIG2 (solid shape): 33.32,11.14 33.41,11.08 33.39,10.96 32.51,10.08 29.44,10.08 28.74,9.38 28.72,9.39 28.55,9.35 28.41,9.23 28.33,9.19 28.25,9.22 26.5,10.96 26.48,11.08 26.58,11.14
DGND on L08_SIG2 (solid shape): 68.82,22.6 68.82,20.09 68.76,20 68.65,20.01 67.94,20.27 67.24,19.99 67.13,19.97 67.07,20.06 67.07,22.13 68.13,23.19 68.13,23.2 68.2,23.23
DGND on L08_SIG2 (solid shape): 60.01,29.87 60.11,29.81 60.08,29.69 59.44,29.05 57.88,29.05 57.79,29.09 57.78,29.18 57.72,29.52 57.41,29.67 57.39,29.67 57.36,29.69 57.34,29.81 57.44,29.87
DGND on L08_SIG2 (solid shape): 72,22.65 72,20.01 71.93,19.91 71.82,19.94 71.01,20.27 70.23,19.88 70.12,19.85 70.05,19.94 70.05,22.39 71.16,23.5
DGND on L08_SIG2 (solid shape): 80.72,24.53 80.83,24.55 80.89,24.46 80.89,20.91 79.01,19.03 78.9,19.01 78.84,19.11 78.84,20.17 79.28,20.62 79.28,20.98 79.32,21.06 79.41,21.08 79.88,21.45 79.41,21.82 79.32,21.84 79.28,21.92 79.28,23.1
DGND on L08_SIG2 (solid shape): 43.19,31.31 43.29,31.25 43.27,31.14 42.83,30.7 42.73,30.68 42.66,30.75 42.2,31.04 41.92,30.57 41.9,30.48 41.82,30.44 40.71,30.44 40.43,30.17 37.36,30.17 37.27,30.23 37.29,30.34 37.78,30.83 41.54,30.83 42.02,31.31
DGND on L08_SIG2 (solid shape): 78.37,24.82 78.48,24.85 78.54,24.75 78.54,21.92 78.5,21.83 78.41,21.82 77.92,21.45 78.41,21.09 78.5,21.07 78.54,20.99 78.54,20.96 78.13,20.54 78.13,18.93 77.73,18.53 77.62,18.51 77.55,18.6 77.55,24.01
DGND on L08_SIG2 (solid shape): 25.7,10.82 25.76,10.91 25.87,10.89 28.13,8.63 28.15,8.52 28.06,8.46 27.77,8.46 27.05,9.19 27.05,9.21 26.4,9.48 26.67,8.83 26.69,8.83 27.07,8.46 27.09,8.35 27,8.28 26.52,8.28 25.7,9.1
DGND on L08_SIG2 (solid shape): 64.98,7.07 65.1,7.09 65.16,7 65.16,4.83 64.44,4.11 64.33,4.08 64.26,4.18 64.26,5.18 64.32,5.27 64.42,5.26 65.02,5.58 64.42,5.89 64.32,5.88 64.26,5.97 64.26,6.35
DGND on L08_SIG2 (solid shape): 35.6,14.17 35.71,14.19 35.78,14.1 35.78,13.87 34.3,12.39 34.22,12.36 34.15,12.4 33.57,12.45 33.61,11.87 33.66,11.8 33.63,11.72 33.55,11.64 28.47,11.64 28.37,11.7 28.39,11.81 28.49,11.91 28.53,11.88 28.77,11.8 29,11.89 29.04,11.92 29.07,11.88 32.34,11.88 34.02,13.56 35,13.56
DGND on L08_SIG2 (solid shape): 37.21,31.21 37.3,31.14 37.28,31.03 29.08,22.84 29.08,17.03 28.95,16.69 29.17,16.4 29.23,16.33 29.2,16.24 29.03,16.07 28.95,16.04 28.88,16.09 28.74,16.2 28.56,16.24 28.54,16.24 28.38,16.41 28.38,23.29 32.04,26.95 32.12,26.98 32.2,26.94 32.63,26.8 32.89,27.17 32.89,27.19 36.9,31.21
DGND on L08_SIG2 (solid shape): 78.73,45.71 78.8,45.81 78.91,45.79 79.86,44.83 79.86,44.53 79.5,44.53 79.29,44.32 79.24,44.24 79.22,44.15 79.22,43.85 79.42,43.65 79.48,43.59 79.29,43.41 79.24,43.33 79.22,43.23 79.22,43.04 79.24,42.95 79.29,42.87 79.42,42.73 79.48,42.68 79.29,42.49 79.24,42.41 79.22,42.32 79.22,42.13 79.24,42.03 79.29,41.95 79.42,41.82 79.48,41.77 79.29,41.58 79.24,41.5 79.22,41.4 79.22,41.21 79.24,41.12 79.29,41.04 79.42,40.9 79.5,40.85 79.6,40.83 79.86,40.83 79.86,39.87 79.8,39.77 79.69,39.79 78.73,40.75
DGND on L08_SIG2 (solid shape): 54.38,11.17 54.47,11.11 54.45,11 50.75,7.3 50.67,7.3 50.59,7.35 50.58,7.44 50.58,7.77 50.32,7.98 50.25,8.05 50.27,8.15 52.55,10.43 52.65,10.45 52.72,10.37 53.37,10.17 53.16,10.82 53.08,10.88 53.11,10.99 53.29,11.17
DGND on L08_SIG2 (solid shape): 66.77,16.41 66.82,16.38 66.81,16.32 66.74,16.25 65,16.25 59.6,10.85 59.6,8.07 61.06,6.62 61.06,6.56 61.06,6.53 61.04,6.45 60.96,6.41 60.22,6.41 60.19,6.44 60.19,6.46 59.97,6.81 59.45,6.73 59.39,6.82 59.39,7.02 58.81,7.59 58.81,11.33 63.4,15.92 63.48,15.95 63.55,15.91 64.04,15.8 64.22,16.27 64.23,16.36 64.31,16.41
DGND on L08_SIG2 (solid shape): 27.02,32.83 27.11,32.78 27.11,32.68 27.05,32.42 27.18,32.18 27.18,31.84 28.86,30.15 28.89,30.04 28.79,29.98 26.95,29.98 26.86,30.03 26.86,30.14 26.54,30.72 26.22,30.14 26.22,30.03 26.13,29.98 26.05,29.98 24.56,28.49 24.45,28.47 24.39,28.57 24.39,30.43 26.8,32.83
DGND on L08_SIG2 (solid shape): 65.49,30.22 65.56,30.31 65.67,30.29 66.3,29.65 66.33,29.55 66.25,29.48 66.03,29.35 65.95,29.1 65.95,29.08 64.94,28.07 64.94,26.28 63.93,25.27 61.98,25.27 61.88,25.34 61.91,25.45 64.15,27.69 64.15,28.78 64.64,29.26 64.7,29.26 64.8,29.2 64.78,29.09 64.28,28.59 64.28,27.12 63.9,26.74 63.88,26.74 63.61,26.09 64.26,26.36 64.26,26.38 64.78,26.91 64.78,28.39 65.49,29.1
DGND on L08_SIG2 (solid shape): 87.27,25.9 87.33,26 87.44,25.97 91.9,21.51 91.9,20.42 91.98,20.34 92,20.23 91.91,20.17 91.53,20.17 90.67,21.02 90.88,21.23 90.93,21.31 90.95,21.4 90.95,21.59 90.93,21.69 90.88,21.77 90.74,21.9 90.66,21.95 90.57,21.97 90.3,21.97 90.3,22.05 90.3,22.24 90.28,22.33 90.23,22.41 90.09,22.55 90.01,22.6 89.92,22.62 89.65,22.62 89.66,22.69 89.66,22.88 89.64,22.98 89.58,23.06 89.45,23.19 89.37,23.25 89.27,23.27 89.01,23.27 89.01,23.34 89.01,23.53 88.99,23.63 88.94,23.71 88.8,23.84 88.72,23.89 88.63,23.91 88.36,23.91 88.36,23.99 88.36,24.28 88.16,24.49 88.07,24.54 87.98,24.56 87.69,24.56 87.4,24.28 87.33,24.28 87.27,24.34
DGND on L08_SIG2 (solid shape): 80.38,42.49 80.45,42.48 80.58,42.44 80.71,42.44 80.8,42.42 80.84,42.34 80.84,41.48 82.43,39.9 82.43,37.98 82.36,37.89 82.25,37.91 80.89,39.28 80.86,39.37 80.92,39.44 81.09,39.99 80.53,40.09 80.42,40.08 80.36,40.17 80.36,40.95 80.34,41.04 80.29,41.12 80.14,41.27 80.12,41.31 80.14,41.35 80.16,41.36 80.29,41.49 80.34,41.58 80.36,41.67 80.36,41.86 80.34,41.96 80.29,42.04 80.14,42.19 80.12,42.23 80.14,42.26 80.16,42.28 80.29,42.41 80.32,42.44
DGND on L08_SIG2 (solid shape): 62.58,28.97 62.69,28.99 62.75,28.9 62.75,27.72 61.08,26.04 60.99,26.04 60.91,26.09 60.89,26.18 60.58,26.61 60.27,26.18 60.25,26.09 60.17,26.04 59.08,26.04 59,26.09 58.99,26.18 59,26.31 58.97,26.44 58.97,26.54 59.05,26.59 60.19,26.59 61.63,28.03 61.73,28.05 61.8,27.98 62.44,27.81 62.27,28.45 62.2,28.52 62.22,28.62
DGND on L08_SIG2 (solid shape): 57.35,36.17 57.43,36.14 57.45,36.06 57.78,35.7 58.11,36.06 58.14,36.14 58.21,36.17 58.95,36.17 59.03,36.14 59.05,36.06 59.05,36.02 59.05,35.98 59.03,35.9 58.95,35.87 58.32,35.87 57.96,35.51 57.93,35.53 57.58,35.49 57.46,35.15 57.46,35.09 57.3,35.09 57.3,35.15 56.78,35.49 56.98,34.9 57,34.9 57.05,34.85 56.96,34.76 56.94,34.76 56.75,34.66 56.65,34.47 56.65,34.45 56.56,34.36 56.51,34.41 56.51,34.43 56.14,34.76 55.86,34.35 55.86,34.29 55.7,34.29 55.71,34.44 55.7,34.53 55.69,34.56 56.04,34.91 56.04,36.09 56.12,36.17
DGND on L08_SIG2 (solid shape): 33.17,16.04 33.25,16 33.27,15.92 33.5,15.51 33.95,15.63 34.03,15.67 34.11,15.63 34.15,15.59 34.19,15.55 34.23,15.48 34.2,15.4 33.39,14.59 33.3,14.56 33.23,14.62 32.62,14.71 32.72,14.1 32.77,14.03 32.74,13.94 31.61,12.81 30.89,12.81 30.44,12.91 30.23,12.5 30.2,12.42 30.13,12.38 29.28,12.38 29.23,12.43 29.05,12.43 28.85,12.55 28.62,12.54 28.53,12.55 28.48,12.63 28.48,13.36 30.77,15.65 30.85,15.68 30.93,15.64 31.23,15.48 31.54,15.63 31.62,15.67 31.7,15.63 32.15,15.51 32.38,15.92 32.4,16 32.48,16.04
DGND on L08_SIG2 (solid shape): 73.49,29.28 73.6,29.3 73.66,29.21 73.66,29.03 74.31,28.39 74.33,28.3 74.28,28.22 74.18,27.61 74.79,27.71 74.86,27.77 74.95,27.74 75.17,27.52 75.17,26.16 75.12,26.07 75.02,26.07 74.42,25.76 75.02,25.44 75.12,25.44 75.17,25.35 75.17,21.69 75.1,21.59 74.99,21.62 74.22,22.05 73.4,21.74 73.29,21.72 73.23,21.82 73.23,22.65 74.16,23.58 74.16,26.13 73.21,27.08 73.21,27.42 73.25,27.5 73.34,27.51 73.81,27.88 73.34,28.25 73.25,28.27 73.21,28.35 73.21,29.01
DGND on L08_SIG2 (solid shape): 52.71,11.53 52.8,11.47 52.78,11.36 49.15,7.73 49.06,7.71 48.99,7.76 48.32,7.82 48.62,7.23 48.68,7.2 48.71,7.13 48.71,7.02 48.67,6.97 48.65,6.97 48.32,6.81 48.29,6.45 48.28,6.35 48.19,6.31 48.06,6.31 47.52,5.76 47.43,5.73 47.36,5.78 46.77,5.84 46.83,5.25 46.88,5.18 46.85,5.1 46.79,5.03 46.79,4.85 46.67,4.64 46.69,4.39 46.69,4.3 46.6,4.25 45.87,4.25 45.79,4.3 45.78,4.39 45.74,4.79 45.38,4.94 45.3,4.96 45.26,5.04 45.26,6.11 45.3,6.19 45.38,6.22 45.81,6.52 45.51,6.96 45.44,7.03 45.46,7.14 49.86,11.53
DGND on L08_SIG2 (solid shape): 63.05,45.65 63.05,45.63 63.17,45.38 63.51,45.28 63.54,45.2 63.54,45.14 63.49,45.14 63.48,45.15 63.05,44.86 63.43,44.5 63.51,44.48 63.54,44.4 63.54,42.86 63.51,42.78 63.43,42.76 63.05,42.38 63.53,42.13 63.56,42.15 63.94,41.77 64.55,41.77 64.63,41.74 64.65,41.66 64.65,41.6 64.63,41.52 64.55,41.49 61.72,41.49 61.64,41.57 61.64,42.8 61.67,42.88 61.75,42.9 62.11,43.25 61.7,43.55 61.64,43.55 61.64,43.71 61.7,43.71 62.11,44.03 61.7,44.35 61.64,44.35 61.64,44.51 61.7,44.51 61.97,44.56 62.11,44.79 62.11,44.81 62.2,44.9 62.25,44.85 62.25,44.83 62.83,44.62 62.53,45.16 62.45,45.18 62.42,45.26 62.42,45.32 62.48,45.32 62.48,45.31 62.76,45.35 62.91,45.59 62.91,45.61 63,45.7
DGND on L08_SIG2 (solid shape): outline of 235 points within 91.01,5.31 98.95,13.39
DGND on L08_SIG2 (solid shape): outline of 248 points within 20.25,23.6 32.73,29.48
DGND on L08_SIG2 (solid shape): outline of 267 points within 49.81,35.25 54.72,40.52
DGND on L08_SIG2 (solid shape): outline of 352 points within 64.04,41.67 68.67,44.51
DGND on L08_SIG2 (solid shape): outline of 482 points within 38.98,2.55 71.18,14.62
DGND on L08_SIG2 (solid shape): outline of 753 points within 15.6,12.87 41.43,33.45
DGND on L08_SIG2 (solid shape): outline of 1355 points within 53.08,29.9 67.53,40.55
DGND on TOP: 68.71,98.92 68.71,97.27 75.69,97.27 75.69,98.92
DGND on TOP: 91.44,58.15 95.25,58.15 95.25,60.44 93.47,60.44 93.47,59.93 92.45,58.92 91.69,58.92 91.44,58.66
DGND on TOP: 100.96,16.12 100.96,18.91 100.07,18.91 99.93,19.05 99.93,20.21 99.12,21.02 99.12,22.79 101.47,25.13 109.34,25.13 109.34,22.09 101.85,22.09 101.85,17.01 105.28,17.01 105.53,16.75 107.18,16.75 107.31,16.88 109.6,16.88 109.6,16.12
DGND on TOP: 96.77,35.81 96.77,37.97 98.29,37.97 98.29,35.81
DGND on TOP: 91.05,21.2 91.05,19.67 93.21,19.67 93.21,21.2
DGND on TOP: 96.77,46.47 96.77,44.31 98.29,44.31 98.29,46.47
DGND on TOP: 108.71,53.33 108.71,47.87 110.74,47.87 110.74,53.33
DGND on TOP: 103.88,54.22 103.88,47.36 105.91,47.36 105.91,54.22
DGND on TOP: 96.39,12.39 99.56,12.39 99.56,15.86 96.77,15.86 96.13,16.5 95.88,16.5 95.88,15.23 96.39,14.72
DGND on BOTTOM: 99.06,48.25 99.06,47.23 100.33,47.23 100.33,49.01 100.07,49.26 100.07,56.12 97.28,56.12 97.28,50.03
DGND on BOTTOM: 103.75,43.17 105.66,43.17 105.66,54.22 103.75,54.22 103.75,47.99 103.37,47.61 103.37,43.55
DGND on BOTTOM: 101.21,25.24 101.21,22.47 105.79,22.47 105.79,25.24
DGND on BOTTOM: 91.05,36.69 91.05,34.4 98.42,34.4 98.42,36.69
DGND on BOTTOM: 90.18,14.71 90.18,12.43 98.84,12.43 98.84,14.71
DGND on BOTTOM: 70.86,42.15 70.86,37.96 72.26,37.96 72.26,42.15
DGND on BOTTOM: 101.09,33.9 101.09,27.92 108.33,27.92 108.33,33.9
DGND on BOTTOM: 98.93,44.56 98.93,36.69 111.25,36.69 111.25,44.56
DGND on BOTTOM: 52.19,81.52 52.19,80.63 53.84,80.63 54.73,79.74 54.73,77.97 54.99,77.71 56.68,77.71 58.56,79.59 61.84,79.59 62.47,80.22 62.47,81.36 61.38,82.45 61.38,82.9 61.11,83.17 58.03,83.17 56.38,81.52
DGND on BOTTOM: 22.35,76.06 22.35,73.01 27.81,73.01 27.81,76.06
DGND on L02_GND1, L09_GND4: 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.53 67.87,2.55 43.25,2.55 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.35 17.42,2.35 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3
DGND on L04_GND2: 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.54 43.25,2.54 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.28 38.77,2.33 17.42,2.33 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3
DGND on L07_GND3: 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.54 43.25,2.54 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.28 38.67,2.43 17.42,2.43 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3
VBUS_MAIN on TOP: 100.83,17.13 100.83,18.15 98.8,18.15 98.55,18.4 98.55,18.91 97.7,19.75 97.7,22 99.06,23.36 99.06,24.12 98.67,24.5 97.91,24.5 96.52,23.1 96.52,18.15 96.26,17.89 95.37,17.89 95.37,17.51 98.04,17.51 98.14,17.42 99.53,17.42 99.81,17.13
VBUS_MAIN on L08_SIG2: 95.75,21.2 95.75,16.75 98.93,16.75 98.93,21.2
VBUS_USBC on TOP: 101.98,22.21 101.98,17.26 105.66,17.26 106.29,17.89 107.69,17.89 107.95,18.15 108.96,18.15 108.96,18.4 107.69,18.4 107.44,18.15 106.17,18.15 106.04,18.28 106.04,20.69 106.17,20.82 107.44,20.82 107.69,20.56 108.96,20.56 108.96,20.94 107.95,20.94 107.69,21.2 106.17,21.2 105.15,22.21
VBUS_USBC on BOTTOM: 101.98,22.22 101.98,18.15 105.41,18.15 105.41,21.72 104.9,22.22
VBUS_USBC on L06_PWR2: 92.07,12.18 92.07,8.88 106.42,8.88 106.42,24.37 97.15,24.37 97.15,17.26
VBUS_XDS110 on TOP: 12.44,95.87 12.44,96.89 14.22,96.89 14.22,100.32 17.78,100.32 17.78,97.02 16.63,95.87
VBUS_XDS110 on L06_PWR2: 22.22,83.68 22.22,104.38 16.63,104.38 14.35,102.1 14.35,84.19 16.25,82.28 20.82,82.28
VCC3V3_XDS on TOP: 18.16,97.65 22.98,97.65 22.98,100.32 18.16,100.32
VCC3V3_XDS on L05_PWR1: 10.02,77.85 10.02,108.19 40.64,108.19 40.64,97.02 41.02,96.63 44.32,96.63 44.57,96.38 44.57,74.41 38.86,74.41 35.49,77.77 10.09,77.77 ; 1 cut-out
VCC_1V2 on TOP: 81.18,50.52 81.18,46.94 84.45,46.94 84.45,50.52
VCC_1V2 on BOTTOM: 81.25,49.87 81.25,46.94 84.71,46.94 84.71,49.87
VCC_1V2 on L05_PWR1: 85.21,49.14 85.21,44.31 77.34,36.44 69.21,36.44 66.47,33.7 57.75,33.7 55.4,36.05 55.4,37.29 55.24,37.45 54.1,37.45 54.1,46.47 57.53,49.9 84.45,49.9 ; 1 cut-out
VCC_1V8_LDO4 on BOTTOM: 105.79,55.49 105.79,48.37 107.06,48.37 107.06,55.49
VCC_1V8_LDO4 on L06_PWR2: 38.86,23.61 38.86,22.09 49.91,22.09 53.46,25.64 53.46,28.69 53.97,29.2 91.82,29.2 99.18,36.56 109.05,36.56 111.6,34.02 113.53,34.02 113.53,45.2 108.96,49.77 106.29,49.77 105.53,49.01 105.53,47.49 88.39,30.34 53.08,30.34 46.35,23.61
VCC_5V0 on L06_PWR2: 64.38,4.05 67.18,4.05 67.18,7.73 66.04,8.88 20.19,8.88 19.3,9.77 19.3,19.04 16.12,22.21 16.12,23.74 17.01,24.63 21.46,24.63 24,22.09 25.01,22.09 25.27,22.34 25.27,25.39 24.76,25.9 15.36,25.9 14.22,24.75 14.22,15.48 16.51,13.2 16.51,9 17.9,7.61 43.34,7.61 46.86,4.09 64.35,4.09 64.38,4.06
VCC_6V0_BBOUT on TOP: 100.83,47.36 100.83,49.77 100.58,50.03 100.58,53.94 99.92,54.6 97.91,54.6 96.77,53.45 96.77,51.4 92.98,47.61 92.32,47.61 90.67,45.96 90.17,45.96 90.17,50.66 91.05,51.55 92.39,51.55 94.36,53.52 94.36,55.61 92.32,57.65 91.31,57.65 91.31,57.9 100.45,57.9 100.81,57.54 100.81,55.51 101.98,54.34 101.98,53.33 101.85,53.2 101.85,47.36
VCC_6V0_BBOUT on BOTTOM: 100.45,56.25 100.45,49.52 100.71,49.26 100.71,47.1 100.45,46.85 100.45,44.95 101.34,44.95 101.34,46.09 101.91,46.66 101.91,56.25
VCC_PLDO1 on BOTTOM: 107.18,36.18 107.18,33.13 109.34,33.13 111.25,35.04 111.25,36.18
VCC_PLDO2 on TOP: 106.55,53.07 106.55,45.2 108.33,45.2 108.33,53.07
VCC_PLDO2 on BOTTOM: 107.56,51.3 107.56,48.25 109.34,48.25 109.34,50.15 112.77,50.15 113.41,50.79 113.41,52.72 113.2,52.93 111.49,52.93 110.88,52.31 108.58,52.31
VDD1V1A on L06_PWR2: 83.94,78.47 83.94,68.19 94.23,68.19 94.23,70.6 89.66,75.17 89.53,75.17 86.23,78.47
VDD2V5A on TOP: 91.82,73.88 91.82,66.92 94.48,66.92 94.48,73.88
VDD_2V5 on TOP: 69.27,89.4 69.27,88 71.24,88 71.37,88.13 72.77,88.13 72.77,88.76 71.88,88.76 71.24,89.4
VDD_2V5 on TOP: 93.09,76.31 93.09,74.28 96.13,74.28 96.13,76.31
VDD_2V5 on TOP: 101.34,83.77 101.34,81.2 102.89,81.2 105.41,83.71 105.41,87.5 102.62,87.5 102.62,84.44 101.95,83.77
VDD_2V5 on BOTTOM: 100.84,86.37 100.84,80.31 103.98,80.31 103.98,85 104.89,85.92 104.89,87.36 102.7,87.36 101.71,86.37
VDD_2V5 on L05_PWR1: 87.24,73.52 76.07,84.7 69.21,84.7 69.21,89.4 76.96,89.4 79.37,86.98 79.37,85.17 82.47,82.07 85.36,82.07 88.96,78.47 95.88,78.47 95.88,73.52 ; 1 cut-out
VDD_2V5 on L06_PWR2: 96.9,74.19 105.38,82.67 105.38,89.93 102.48,92.82 91.94,92.82 92.07,92.7 92.07,84.19 94.61,81.65 94.61,74.71 95.13,74.19
VDD_5V0_LDO3 on BOTTOM: 10.02,59.3 10.02,61.71 12.19,61.71 12.19,59.3
VDD_5V0_LDO3 on BOTTOM: 103.75,33.9 103.75,31.18 108.07,31.18 108.07,32.75 105.41,32.75 105.15,33.01 105.15,33.9
VDD_5V0_LDO3 on L06_PWR2: 50.02,70.6 17.65,70.6 10.66,63.61 10.66,59.8 10.73,59.74 10.73,59.68 11.55,59.68 12.57,60.69 14.73,60.69 22.6,68.57 51.68,68.57 53.36,70.24 60.85,70.24 69.08,78.47 72.6,78.47 73.27,77.8 73.27,75.68 74.29,75.68 74.29,77.84 72.26,79.87 67.1,79.87 63.67,76.44 55.86,76.44
VDD_IO_3V3 on BOTTOM: 102.36,59.3 102.36,57.96 107.44,57.96 107.44,59.3
VDD_IO_3V3 on BOTTOM: 68.52,41.64 68.52,37.83 70.35,37.83 70.35,42.15 69.03,42.15
VDD_IO_3V3 on L06_PWR2: 50.54,44.56 50.54,38.85 53.59,35.8 53.59,35.67 55.37,35.67 55.62,35.93 55.62,37.07 54.99,37.71 54.99,40.25 56.13,41.39 56.26,41.39 56.26,44.82 57.02,45.58 57.4,45.58 58.29,44.69 58.29,44.56 58.67,44.18 63.75,44.18 64.26,44.69 65.4,44.69 65.91,44.18 65.91,43.29 64.51,41.9 64.51,38.34 65.78,37.07 65.78,36.94 65.4,36.56 65.4,34.28 65.53,34.15 78.35,34.15 82.29,38.09 93.59,38.09 106.93,51.42 106.93,58.66 106.17,59.42 101.98,59.42 92.83,50.28 56.26,50.28
VDD_MMC1 on TOP: 15.74,58.15 15.74,55.74 24.25,55.74 24.25,58.15
VDD_MMC1 on L05_PWR1: 20.95,57.26 20.95,50.41 24.63,50.41 24.63,57.26
VDDA1V8_OSC_PLL_F on L03_SIG1: 55.31,34.67 55.9,34.67 55.9,36.02 54.27,36.02 53.2,34.71 53.2,32.8 50.02,29.61 50.02,28.87 49.26,28.12 49.26,28.12 49.26,27.66 49.38,27.54 50.17,27.54 50.68,28.05 50.68,28.81 54.33,32.46 54.33,33.7
VDDA3V3_F on L06_PWR2: 57.4,37.2 57.4,35.67 59.28,35.67 59.28,35.35 59.59,35.04 59.59,32.08 60.57,31.1 70.35,31.1 71.37,32.12 71.37,32.88 71.02,33.23 70.32,33.23 69.08,31.99 63.07,31.99 62.04,33.02 62.04,36.56 61.4,37.2
VDDA_IO_1V8 on BOTTOM: 58.23,35.91 58.23,34.63 59.75,34.63 60.4,33.98 62.11,33.98 62.36,34.22 62.36,35.91
VDDA_IO_1V8 on L06_PWR2: 33.14,26.4 31.49,24.75 31.49,23.74 32,23.23 33.52,23.23 34.41,24.12 39.87,24.12 39.94,24.18 45.65,24.18 52.32,30.85 57.15,30.85 59.09,32.79 59.09,35.16 58.7,35.55 56.89,35.55 56.64,35.29 56.64,33.39 56.07,32.82 56,32.88 53.34,32.88 51.94,34.28 50.67,34.28 48.32,31.93 48.32,29.39 45.33,26.4
VDDA_IO_3V3 on L06_PWR2: 65.91,14.97 65.91,25.26 53.46,25.26 49.78,21.58 31.49,21.58 28.57,24.5 26.03,24.5 26.03,22.21 23.36,19.55 23.36,16.24 21.71,14.59 21.71,14.21 23.24,12.69 63.62,12.69
VDDIO on TOP: 83.31,65.39 85.6,65.39 85.6,66.68 85.2,66.68 84.83,67.04 84.83,67.68 84.39,68.12 83.31,68.12
VDDIO on TOP: 69.46,97.27 69.46,95.75 72.77,95.75 72.77,97.27
VDDIO on BOTTOM: 90.65,81.44 90.65,82.95 88.49,82.95 88.49,81.44
VDDIO on L06_PWR2: 68.96,97.27 68.96,91.68 74.67,85.97 74.67,61.96 95.37,61.96 95.5,61.84 99.18,61.84 99.69,61.33 99.69,59.55 99.82,59.42 100.71,59.42 100.83,59.55 100.83,69.96 97.79,73.01 95.5,73.01 93.98,74.54 93.98,80.51 91.44,83.05 91.44,91.3 91.05,91.68 76.32,91.68 72.77,95.24 72.77,97.14 72.64,97.27
VDDS_IO_1V8 on L06_PWR2: 55.88,37.45 55.88,35.55 55.24,34.91 54.48,34.91 53.97,35.42 44.57,35.42 41.65,32.5 41.65,30.72 42.03,30.34 42.67,30.34 42.92,30.59 42.92,31.74 44.51,33.32 48.27,33.32 49.86,34.91 52.57,34.91 53.97,33.52 55.62,33.52 56.19,34.09 56.19,35.36 56.89,36.06 56.89,37.2 57.53,37.83 61.72,37.83 62.46,37.09 62.46,33.42 63.64,32.25 68.58,32.25 69.08,32.75 69.08,33.64 68.96,33.77 67.31,33.77 67.18,33.9 65.15,33.9 64.64,34.4 64.64,36.06 65.15,36.56 65.15,37.07 64.13,38.09 64.13,42.02 65.27,43.17 65.27,44.18 65.15,44.31 64.64,44.31 64.13,43.8 58.42,43.8 57.15,45.07 56.89,45.07 56.64,44.82 56.64,41.26 55.37,39.99 55.37,37.96
(no net) on TOP: 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.36 113.74,108.36 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.53 67.87,2.55 43.25,2.55 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.35 17.42,2.35 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 ; 100 cut-outs
(no net) on BOTTOM: 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.53 67.87,2.55 43.25,2.55 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.35 17.42,2.35 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 ; 126 cut-outs
(no net) on L03_SIG1: 67.88,7.1 67.88,2.54 43.25,2.54 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.28 38.77,2.33 17.42,2.33 17.42,7.1 15.27,7.1 15.27,13.03 15,13.3 10.02,13.3 10.02,18.91 12.7,18.91 13.58,19.8 13.58,22.09 13.84,22.34 14.73,22.34 15.36,21.7 15.9,21.7 16.4,22.21 19.3,22.21 19.3,23.1 16.38,23.1 15.87,23.61 15.24,23.61 14.85,23.23 13.84,23.23 13.71,23.36 13.71,24.88 12.31,26.28 10.02,26.28 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 70.87,108.19 74.81,104.25 78,104.25 81.6,107.85 107.59,107.85 113.74,101.7 113.74,78.73 101.6,78.73 101.6,59.3 113.74,59.3 113.74,26.15 105.66,26.15 105.66,23.47 106.54,22.59 109.98,22.59 109.98,16.37 105.78,16.37 105.41,16 105.41,11.16 113.74,11.16 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3 70.35,8.88 70.64,7.84 71.43,7.1 ; 161 cut-outs
(no net) on L08_SIG2: 38.82,2.35 17.42,2.35 17.42,7.1 13.83,7.1 14.63,7.85 14.93,8.9 14.93,13.3 10.02,13.3 10.02,76.95 10.27,76.7 34.79,76.7 37.97,73.52 45.08,73.52 45.46,73.9 45.46,96.63 44.83,97.27 41.65,97.27 41.27,97.65 41.27,108.19 113.74,108.19 113.74,7.1 112.15,7.1 112.15,2.65 88.9,2.65 88.9,13.3 70.35,13.3 70.35,8.88 70.64,7.84 71.43,7.1 67.88,7.1 67.88,2.53 67.87,2.55 43.25,2.55 43.25,5.2 41.04,7.42 38.82,5.2 ; 239 cut-outs
ADC_DAC-VREF on TOP: 35.52,27.01 35.52,24.28 37.73,24.28 37.73,27.01
ADC_DAC-VREF on BOTTOM: 28.25,25.29 28.25,23.37 36.12,23.37 36.12,25.29
ADC_VREF1 on BOTTOM: 28.2,23.2 28.2,21.67 31.61,21.67 31.61,23.2
ADC_VREF2 on BOTTOM: 27.49,26.34 27.49,25.37 30.54,25.37 30.54,26.34
ADC_VREF3 on BOTTOM: 33.14,23.15 33.14,21.81 36.15,21.81 36.15,23.15
AM263_DAC_VREF on BOTTOM: 33.06,26.36 33.06,25.42 36.2,25.42 36.2,26.36
AM263_DAC_VREF0 on TOP: 27.94,27.59 27.94,24.99 32.86,24.99 32.86,27.59
ETH_EARTH on TOP: 102.23,78.09 102.23,59.93 113.75,59.93 113.75,78.09
ETH_EARTH on BOTTOM: 102.23,78.09 102.23,59.93 113.74,59.93 113.74,78.09 ; 1 cut-out
ETH_EARTH on L02_GND1, L03_SIG1, L04_GND2, L05_PWR1, L06_PWR2, L07_GND3, L08_SIG2, L09_GND4: 102.23,78.09 102.23,59.93 113.15,59.93 113.15,78.09
HSEC_5V0 on TOP: 90.55,19.29 90.55,18.53 92.07,18.53 93.09,17.51 95.12,17.51 95.12,17.89 94.1,17.89 93.85,18.15 93.85,18.66 93.21,19.29
HSEC_5V0 on BOTTOM: 88.39,20.05 88.39,18.58 92.83,18.58 92.83,20.05
HSEC_5V0 on L05_PWR1: 30.73,2.65 30.73,10.27 32.25,11.8 55.49,11.8 60.45,16.75 88.13,16.75 89.02,15.86 91.94,15.86 92.58,16.5 92.58,18.41 92.47,18.52 90.81,18.52 90.55,18.78 90.55,19.67 90.67,19.67 90.67,20.31 95.75,25.39 98.67,25.39 102.99,21.07 102.99,12.81 105.28,10.53 112.39,10.53 112.39,5.58 94.36,5.58 89.28,10.66 89.28,13.22 88.41,14.08 71.24,14.08 69.21,12.05 69.21,7.1 67.88,7.1 67.88,2.65 43.25,2.65 43.25,5.2 41.04,7.42 38.82,5.2 38.82,2.65
OPSI_DQS on BOTTOM: 31.34,44.47 31.34,42.01 32.82,42.01 32.82,44.47
USBC_EARTH on TOP, L03_SIG1, L04_GND2, L05_PWR1: 106.04,11.8 106.04,15.74 110.61,15.74 110.61,23.23 106.8,23.23 106.29,23.74 106.29,25.51 113.79,25.51 113.79,11.8
USBC_EARTH on BOTTOM: 106.04,11.8 106.04,15.74 110.61,15.74 110.61,23.23 106.8,23.23 106.29,23.74 106.29,25.51 113.79,25.51 113.79,11.8
USBC_EARTH on L02_GND1, L06_PWR2, L07_GND3: 106.04,11.8 106.04,15.74 110.61,15.74 110.61,23.23 106.8,23.23 106.29,23.74 106.29,25.51 113.78,25.51 113.78,11.8
USBC_EARTH on L08_SIG2, L09_GND4: 106.04,11.8 106.04,15.74 110.61,15.74 110.61,23.23 106.8,23.23 106.29,23.74 106.29,25.51 113.79,25.51 113.79,11.8
VMAIN on TOP: 92.96,15.23 93.47,15.74 93.47,16.37 93.85,16.75 96.52,16.75 97.02,16.24 99.49,16.24 99.49,17.13 92.83,17.13 91.82,18.15 90.44,18.15 90.12,18.47 90.12,19.14 87.88,19.14 87.88,16.09 88.74,15.23
VMAIN on TOP: 53.34,78.11 53.34,77.23 53.88,77.23 54.1,77.02 54.1,72.06 57.88,68.28 57.88,65.96 58.31,65.53 58.31,63.67 58.47,63.51 58.99,63.51 59.15,63.68 59.15,66.24 59.69,66.78 59.69,67.99 59.19,68.49 59.19,69.8 56.03,72.96 56.03,77.56 55.48,78.11
VMAIN on BOTTOM: 90,18.02 90,15.1 98.67,15.1 98.67,18.02
VMAIN on BOTTOM: 53.84,80.38 53.84,79.32 53.33,78.81 53.29,78.85 52.77,78.85 52.7,78.79 52.7,77.49 53.05,77.14 55,77.14 55.24,77.38 55.24,77.71 55.11,77.84 55.11,78.47 54.1,79.49 54.1,80.38
VMAIN on BOTTOM: 97.42,90.48 97.42,86.94 100.09,86.94 100.09,90.48
VMAIN on L05_PWR1: 89.4,16.5 91.82,16.5 91.94,16.62 91.94,18.02 90.55,18.02 90.04,18.53 90.04,21.83 94.23,26.02 102.61,26.02 113.53,36.94 113.53,56.63 110.74,59.42 102.99,59.42 101.47,60.95 101.47,93.59 92.83,102.22 78.1,102.22 75.31,99.43 67.05,99.43 53.46,85.84 53.46,76.95 55.24,76.95 55.37,77.08 55.37,78.22 56.95,79.81 56.95,85.27 67.75,96.06 76,96.06 79.12,99.17 90.04,99.17 96.39,92.82 96.39,61.84 103.37,54.85 107.26,54.85 110.73,51.38 110.73,44.46 109.8,43.53 109.8,38.16 107.31,35.67 106.17,35.67 99.31,28.82 92.58,28.82 87.75,23.99 87.75,18.15
VMAIN on L06_PWR2: 92.32,17.39 92.32,25.39 88.9,28.82 54.22,28.82 53.72,28.31 53.72,27.04 54.55,26.2 78.46,26.2 82.8,26.02 87.37,21.45 87.37,17.39
VMAIN_12V0 on TOP: 89.91,34.28 89.91,27.55 88.51,26.15 88.51,22.47 89.15,21.83 94.86,21.83 95.85,22.82 95.85,27.06 94.86,28.05 94.86,34.28
VMAIN_12V0 on L06_PWR2: 16.76,23.86 16.76,22.85 19.81,19.8 19.81,11.93 21.84,9.89 66.82,9.89 70.5,13.58 92.58,13.58 96.64,17.64 96.64,26.02 100.71,30.09 100.71,34.15 100.58,34.28 98.42,34.28 93.09,28.94 93.09,17.26 92.32,16.5 85.97,16.5 83.82,18.66 83.82,20.43 78.61,25.64 68.96,25.64 66.8,23.48 66.8,14.47 64.13,11.8 22.73,11.8 21.2,13.32 21.2,14.85 22.35,15.99 22.35,20.31 21.59,21.07 21.2,21.07 21.2,22.21 19.55,23.86
VMAINP_12V0 on TOP: 99.9,28.65 101.53,30.28 101.53,35.1 101.85,35.42 101.85,38.09 100.58,38.09 100.58,35.67 99.06,34.15 95.25,34.15 95.25,28.65
VMAINP_12V0 on BOTTOM: 100.33,28.02 100.33,29.78 100.96,30.42 100.96,33.83 91.09,33.83 91.09,31.75 94.81,28.02
VPP_1V7 on TOP: 84.96,46.6 84.96,45.04 85.55,44.45 86.38,44.45 86.38,45.83 87.49,45.83 87.63,45.96 88.51,45.96 88.51,46.6
VPP_R on L05_PWR1: 50.54,37.07 50.54,35.67 54.86,35.67 54.86,37.07
VSYS_1V2 on TOP: 82.99,52.46 82.99,51.12 86.33,51.12 86.33,52.13 86.54,52.33 87.9,52.33 88.16,52.59 88.16,54.24 89.14,55.23 90.03,55.23 90.8,55.99 90.8,57.14 89.78,57.14 89.27,56.62 84.85,56.62 84.85,54.33
VSYS_1V2 on BOTTOM: 82.17,51.83 82.17,50.33 84.79,50.33 84.8,50.34 84.8,50.65 86.28,52.13 86.28,54.44 84.78,54.44
VSYS_1V2_SW on TOP: 84.85,58.95 84.85,57.01 91.05,57.01 91.05,57.52 90.03,57.52 88.59,58.95
VSYS_3V3_LDO1 on TOP: 102.45,54.45 102.45,44.31 103.34,44.31 103.34,49.74 103.75,50.15 103.75,56.88 101.62,56.88 101.24,56.5 101.24,55.66
VSYS_3V3_LDO1 on BOTTOM: 102.23,57.58 102.23,47.6 104.01,47.6 104.01,57.58
VSYS_3V3_LDO1 on BOTTOM: 62.61,12.69 62.61,9.89 66.23,9.89 67.45,11.12 67.45,12.69
VSYS_3V3_LDO1 on L05_PWR1: 10.02,13.3 10.02,108.19 113.74,108.19 113.74,43.76 109.41,39.42 108.9,39.42 98.86,29.39 92.01,29.39 80.07,17.45 60.18,17.45 56.03,13.3 ; 6 cut-outs
VSYS_3V3_LDO1 on L06_PWR2: 73.02,93.21 73.02,108.19 101.72,108.19 101.72,93.21
VSYS_3V3_LDO2 on TOP: 102.48,37.2 102.48,34.79 103.5,34.79 103.63,34.66 103.63,34.28 104.14,34.28 104.14,35.67 104.01,35.8 103.12,35.8 103.12,37.2
VSYS_3V3_LDO2 on TOP: 11.04,58.79 11.04,56.76 14.73,56.76 14.73,58.79
VSYS_3V3_LDO2 on BOTTOM: 101.47,38.21 101.47,34.25 105.02,34.25 105.02,38.21
VSYS_3V3_LDO2 on L03_SIG1: 103.59,36.95 103.59,34.17 105.62,34.17 105.62,36.95
VSYS_3V3_LDO2 on L06_PWR2: 11.68,59.17 11.68,49.64 24.25,37.07 24.25,27.04 37.71,27.04 37.71,36.82 53.21,52.31 87.88,52.31 88.51,52.95 88.51,61.33 74.42,61.33 72.77,62.98 72.77,77.56 72.36,77.97 69.46,77.97 69.21,77.71 69.21,73.83 64.43,69.05 54.6,69.05 52.84,67.3 22.35,67.3 15.24,60.19 12.7,60.19
VSYS_TA_3V3 on BOTTOM: 44.83,102.98 44.83,101.46 45.21,101.07 45.21,97.66 45.22,97.65 46.35,97.65 46.35,102.98
VSYS_TA_3V3 on BOTTOM: 54.35,82.66 54.35,81.9 56.13,81.9 57.79,83.56 61.34,83.56 61.34,87.57 55.65,87.57 55.25,87.17 55.25,83.56
VSYS_TA_3V3 on L06_PWR2: 43.3,108.06 43.3,99.05 46.22,96.13 46.22,74.79 44.32,72.89 16.4,72.89 16.25,72.73 16.25,71.41 16.43,71.23 48.89,71.23 54.73,77.08 63.47,77.08 67.75,81.36 67.75,108.06
VSYS_TA_3V3_SW on BOTTOM: 53.84,82.03 54.1,82.03 54.1,83.28 54.78,83.96 54.78,87.42 54.58,87.62 52.95,87.62 52.7,87.36 52.7,83.81 53.84,82.66
XDS_GND on TOP: 10.02,84.7 10.02,88 14.47,88 14.47,84.7
XDS_GND on TOP: 10.02,77.71 10.02,108.19 40.64,108.19 40.64,97.02 41.27,96.38 44.57,96.38 44.57,74.92 43.94,74.28 38.86,74.28 38.86,74.41 35.56,77.71 ; 2 cut-outs
XDS_GND on BOTTOM: 10.41,87.87 10.41,85.2 14.09,85.2 14.09,87.87
XDS_GND on BOTTOM: 10.02,77.84 10.02,106.43 11.78,108.19 40.64,108.19 40.64,96.63 44.32,96.63 44.57,96.38 44.57,74.94 44.6,74.94 44.06,74.41 38.92,74.41 35.49,77.84 ; 2 cut-outs
XDS_GND on BOTTOM: 21.84,80.51 21.84,78.22 27.68,78.22 27.68,80.51
XDS_GND on L02_GND1, L03_SIG1, L04_GND2, L07_GND3, L09_GND4: 10.02,77.85 10.02,108.19 40.64,108.19 40.64,97.02 41.02,96.63 44.32,96.63 44.57,96.38 44.57,74.41 38.86,74.41 35.49,77.77 10.09,77.77 ; 1 cut-out
XDS_GND on L06_PWR2: 10.02,77.85 10.02,108.19 40.64,108.19 40.64,97.02 41.02,96.63 44.32,96.63 44.57,96.38 44.57,74.41 38.86,74.41 35.49,77.77 10.09,77.77 ; 2 cut-outs
