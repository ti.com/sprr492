# Allegro board PROC159A.brd (continued)
## Nets (continued)
ADC_CAL1/ADC_R0_AIN1: U70.6(D2) U75.7(S2B)
ADC_CAL2: J14.1 U1.U17(ADC_CAL2) U65.4(IO3)
ADC_CAL3: J14.2 U1.N17(ADC_CAL3) U65.6(IO4)
ADC_DAC-VREF: SW7.2(COM) U67.3(+INA) U67.5(+INB) U67.12(+INC) U67.14(+IND)
ADC_R0_AIN0: U1.T18(ADC_R0_AIN0) U73.3(1B2)
ADC_R0_AIN1: U1.T16(ADC_R0_AIN1) U70.7(S2B)
ADC_R0_AIN2: U1.U18(ADC_R0_AIN2) U72.3(1B2)
ADC_R0_AIN3: U1.T17(ADC_R0_AIN3) U72.6(2B2)
ADC_R1_AIN0: U1.R16(ADC_R1_AIN0) U73.6(2B2)
ADC_R1_AIN1: U1.R18(ADC_R1_AIN1) U70.9(S1B)
ADC_R1_AIN2: U1.P18(ADC_R1_AIN2) U72.10(3B2)
ADC_R1_AIN3: U1.P17(ADC_R1_AIN3) U72.13(4B2)
ADC_VREF1: SW9.3 U67.1(OUTA) U67.2(-INA)
ADC_VREF2: SW9.6 U67.6(-INB) U67.7(OUTB)
ADC_VREF3: SW13.3 U67.15(-IND) U67.16(OUTD)
ADC_VREFHI_G0_G1: R401.2 SW9.2
ADC_VREFHI_G0_G1_R: C285.1 C286.1 C287.1 R401.1 U1.V10(ADC_VREFHI_G1) U1.V14(ADC_VREFHI_G0)
ADC_VREFHI_G2: R402.2 SW9.5
ADC_VREFHI_G2_R: C288.1 C289.1 R402.1 U1.V6(ADC_VREFHI_G2)
ADC_VREFHI_G3: R1648.1 SW13.2(COM)
ADC_VREFHI_G3_R: C349.1 C350.1 R1648.2 U1.V17(ADC_VREFHI_G3)
AM263_ADC_VREFLO_1: C285.2 C286.2 C287.2 R404.2 U1.V11(ADC_VREFLO_G1) U1.V13(ADC_VREFLO_G0)
AM263_ADC_VREFLO_2: C288.2 C289.2 R403.2 U1.V7(ADC_VREFLO_G2)
AM263_ADC_VREFLO_3: C349.2 C350.2 R1649.2 U1.V16(ADC_VREFLO_G3)
AM263_DAC_VREF: SW8.3 U67.10(OUTC) U67.11(-INC)
AM263_DAC_VREF0: C279.1 C280.1 SW8.2(COM) U1.T6(DAC_VREF1) U1.T13(DAC_VREF0)
BOOTMODE_TA_I2C_SCL: R286.2 R303.1 R361.2 U47.12(SCL)
BOOTMODE_TA_I2C_SDA: R287.2 R305.1 R362.2 U47.13(SDA)
BOOTMODE_XDS_I2C_SCL: R360.2 U52.49(PG0) U56.3(SCL1)
BOOTMODE_XDS_I2C_SDA: R359.2 U52.50(PG1) U56.2(SDA1)
BOOTMODEON: R329.1 R330.2 U48.1(1\O\E\) U48.16(2\O\E\)
C_A5_CC1: D1.1(CATHODE) J1.A5(CC1) U17.1(CC1)
C_B5_CC2: D2.1(CATHODE) J1.B5(CC2) U17.2(CC2)
CLK_BUF_EN: R276.1 U41.2(1G) U60.2(P01)
CLK_OUT2: TP62.1(TP) U35.40(CLK_OUT)
CLOCKOUT0: R271.1 U1.M2(CLKOUT0)
DIR1: R322.1 U48.4(1DIR) U48.5(2DIR)
EEPROM_A1: R168.2 U28.2(A1)
EEPROM_A2: R169.2 U28.3(A2)
EEPROM_WP: R167.2 R170.2 U28.7(WP)
EPWM7_A: R3880.1 R3881.1 U1.F4(EPWM7_A)
EPWM7_B: R3876.1 R3877.1 U1.F1(EPWM7_B)
EPWM10_B: R193.1 R3879.1 U1.J3(EPWM10_B)
EPWM11_A: R190.1 R3865.1 U1.H1(EPWM11_A)
ETH_EARTH: J7.15(SH1) J7.16(SH2)
ETH_EEPROM_A0: J8.47 R3875.1
ETH_EEPROM_A2: J8.37 R3874.1
ETH_LED1: LD11.1(CATHODE) U59.3(DRAIN0)
ETH_LED2: LD12.1(CATHODE) U59.4(DRAIN1)
ETH_LED3: LD13.1(CATHODE) U59.5(DRAIN2)
ETH_LED4: LD14.1(CATHODE) U59.6(DRAIN3)
ETH_LED5: LD15.1(CATHODE) U59.11(DRAIN4)
ETH_LED6: LD16.1(CATHODE) U59.12(DRAIN5)
ETH_LED7: LD17.1(CATHODE) U59.13(DRAIN6)
ETH_LED8: LD18.1(CATHODE) U59.14(DRAIN7)
EXT_VMON1: R53.2 R55.2 TP85.1(TP) U7.16(EXT_VMON1)
EXT_VMON2: J8.2 U7.10(EXT_VMON2)
FSI_MUX_OE#: R206.1 U33.15(O\E\)
FSI_MUX_SEL: R204.2 R205.1 U33.1(S) U60.5(P04)
FSIRX2_CLK: J6.1 U33.6(2B2)
FSIRX2_CLK/MCAN4_TXD: U1.J2(EPWM9_B) U33.7(2A)
FSIRX2_DATA0: J6.5 U33.10(3B2)
FSIRX2_DATA0/MCAN5_RXD: U1.G4(EPWM10_A) U33.9(3A)
FSIRX2_DATA1: J6.7 U33.13(4B2)
FSIRX2_DATA1/MCAN5_TXD: R193.2 U33.12(4A)
FSITX2_CLK: J6.2 U1.G3(EPWM8_A)
FSITX2_DATA0: J6.6 U1.H2(EPWM8_B)
FSITX2_DATA1: J6.8 U33.3(1B2)
FSITX2_DATA1/MCAN4_RXD: U1.G1(EPWM9_A) U33.4(1A)
GPIO_2/CLKOUT: J8.48
GPIO_ICSSM1_RST: R217.1 U1.N18(GPIO35) U36.1(A)
GPIO_ICSSM2_RST: R265.1 U1.M18(GPIO36) U39.1(A)
GPIO_USD_PWR_EN: R125.1 U22.2(B) U60.8(P07)
HSEC_5V0: C13.1 C14.1 C15.1 C332.1 C333.1 C334.1 J15.48 J15.84 J15.98 J15.112 J15.118 J15.158 J15.180 R12.1 R13.1 TP81.1(TP) U4.7(IN1)
HSEC_ADC0_AIN0: U1.V15(ADC0_AIN0) U74.2(S1A)
HSEC_ADC0_AIN0/DAC_OUT: C290.1 J15.9 U61.1(IO1) U74.10(D1)
HSEC_ADC0_AIN1: U1.U15(ADC0_AIN1) U74.4(S2A)
HSEC_ADC0_AIN1/DAC_OUT: C291.1 J15.11 U61.3(IO2) U74.6(D2)
HSEC_ADC0_AIN2: C292.1 J15.15 U1.T14(ADC0_AIN2) U62.6(IO4)
HSEC_ADC0_AIN3: C293.1 J15.17 U1.U14(ADC0_AIN3) U62.4(IO3)
HSEC_ADC0_AIN4: C294.1 J15.21 U1.U13(ADC0_AIN4) U63.6(IO4)
HSEC_ADC0_AIN5: C295.1 J15.23 U1.R14(ADC0_AIN5) U63.4(IO3)
HSEC_ADC1_AIN0: C296.1 J15.12 U1.T11(ADC1_AIN0) U62.1(IO1)
HSEC_ADC1_AIN1: C297.1 J15.14 U1.U11(ADC1_AIN1) U62.3(IO2)
HSEC_ADC1_AIN2: C298.1 J15.18 U1.T12(ADC1_AIN2) U63.1(IO1)
HSEC_ADC1_AIN3: C299.1 J15.20 U1.V12(ADC1_AIN3) U63.3(IO2)
HSEC_ADC1_AIN4: C302.1 J15.24 U1.U12(ADC1_AIN4) U64.1(IO1)
HSEC_ADC1_AIN5: C303.1 J15.26 U1.R12(ADC1_AIN5) U64.3(IO2)
HSEC_ADC2_AIN0: U1.R10(ADC2_AIN0) U73.5(2B1)
HSEC_ADC2_AIN0/ADC_R1_AIN0: C322.1 J15.31 U69.3(IO2) U73.7(2A)
HSEC_ADC2_AIN1: U1.T10(ADC2_AIN1) U70.2(S1A)
HSEC_ADC2_AIN1/ADC_R1_AIN1: C321.1 J15.33 U69.1(IO1) U70.10(D1)
HSEC_ADC2_AIN2: C304.1 C308.1 J15.37 U1.U10(ADC2_AIN2) U65.1(IO1)
HSEC_ADC2_AIN3: C305.1 C309.1 J15.39 U1.T9(ADC2_AIN3) U65.3(IO2)
HSEC_ADC3_AIN0: U1.U7(ADC3_AIN0) U72.2(1B1)
HSEC_ADC3_AIN0/ADC_R0_AIN2: C324.1 J15.28 U69.4(IO3) U72.4(1A)
HSEC_ADC3_AIN1: U1.U8(ADC3_AIN1) U72.5(2B1)
HSEC_ADC3_AIN1/ADC_R0_AIN3: C323.1 J15.30 U69.6(IO4) U72.7(2A)
HSEC_ADC3_AIN2: U1.T7(ADC3_AIN2) U72.11(3B1)
HSEC_ADC3_AIN2/ADC_R1_AIN2: C320.1 J15.34 U68.4(IO3) U72.9(3A)
HSEC_ADC3_AIN3: U1.R7(ADC3_AIN3) U72.14(4B1)
HSEC_ADC3_AIN3/ADC_R1_AIN3: C319.1 J15.36 U68.6(IO4) U72.12(4A)
HSEC_ADC3_AIN4: C300.1 J15.40 U1.V8(ADC3_AIN4) U64.6(IO4)
HSEC_ADC3_AIN5: C301.1 J15.42 U1.U9(ADC3_AIN5) U64.4(IO3)
HSEC_ADC4_AIN0: U1.U6(ADC4_AIN0) U75.2(S1A)
HSEC_ADC4_AIN1: U1.V5(ADC4_AIN1) U75.4(S2A)
HSEC_ADC-VREFHI: C331.1 R417.2 R418.1 SW7.3
HSEC_DAC_OUT: R412.2 R413.2 U1.T5(DAC_OUT)
HSEC_EPWM0_A: J15.49 U1.B2(EPWM0_A)
HSEC_EPWM0_B: J15.51 U1.B1(EPWM0_B)
HSEC_EPWM1_A: J15.53 U1.D3(EPWM1_A)
HSEC_EPWM1_B: J15.55 U1.D2(EPWM1_B)
HSEC_EPWM2_A: J15.50 U1.C2(EPWM2_A)
HSEC_EPWM2_B: J15.52 U1.C1(EPWM2_B)
HSEC_EPWM3_A: U1.E2(EPWM3_A) U73.11(3B1)
HSEC_EPWM3_A/HSEC_MII1_CRS(RES0: C318.1 J15.54 U68.3(IO2) U73.9(3A)
HSEC_EPWM3_B: J15.56 U1.E3(EPWM3_B)
HSEC_EPWM4_A: J15.57 U1.D1(EPWM4_A)
HSEC_EPWM4_B: J15.59 U1.E4(EPWM4_B)
HSEC_EPWM5_A: J15.61 U1.F2(EPWM5_A)
HSEC_EPWM5_B: J15.63 U1.G2(EPWM5_B)
HSEC_EPWM6_A: J15.58 U1.E1(EPWM6_A)
HSEC_EPWM6_B: J15.60 U1.F3(EPWM6_B)
HSEC_EPWM7_A: J15.62 R3880.2
HSEC_EPWM7_B: J15.64 R3876.2
HSEC_EPWM11_A: J15.86 R190.2
HSEC_EPWM13_A: J15.153 R192.2
HSEC_EPWM13_B: J15.154 R196.2
HSEC_EPWM21_A: J15.89 R209.2
HSEC_EPWM21_B: J15.90 R207.2
HSEC_EQEP0_A: J15.102 U1.B14(EQEP0_A)
HSEC_EQEP0_B: J15.100 U1.A14(EQEP0_B)
HSEC_EQEP0_INDEX: J15.106 U1.D11(EQEP0_INDEX)
HSEC_EQEP0_STROBE: J15.104 U1.C12(EQEP0_STROBE)
HSEC_EQEP2_A: J15.92 U26.6(2B2)
HSEC_EQEP2_B: J15.93 U26.3(1B2)
HSEC_EQEP2_INDEX: J15.94 U1.A12(MCAN2_RX)
HSEC_EQEP2_STROBE: J15.95 U1.B12(MCAN2_TX)
HSEC_EXT_REFCLK0: J15.74 U1.P2(EXT_REFCLK0)
HSEC_GPIO: J15.96 U60.17(P20)
HSEC_I2C1_SCL: J15.87 R152.2 U1.D7(I2C1_SCL)
HSEC_I2C1_SDA: J15.85 R153.2 U1.C8(I2C1_SDA)
HSEC_MCAN5_RX: J15.80 U33.11(3B1)
HSEC_MCAN5_TX: J15.82 U33.14(4B1)
HSEC_MII0_COL: J15.110 U87.24(C8)
HSEC_MII0_CRS: J15.121 U87.22(C9)
HSEC_MII0_RXCLK: J15.123 U87.28(C6)
HSEC_MII0_RXD0: J15.125 U87.42(C0)
HSEC_MII0_RXD1: J15.126 U87.40(C1)
HSEC_MII0_RXD2: J15.127 U87.37(C2)
HSEC_MII0_RXD3: J15.128 U87.35(C3)
HSEC_MII0_RXDV: J15.124 U87.33(C4)
HSEC_MII0_RXER: J15.108 U87.31(C5)
HSEC_MII0_RXLINK: J15.122 U87.26(C7)
HSEC_MII0_TXCLK: J15.129 U88.40(C1)
HSEC_MII0_TXD0: J15.131 U88.37(C2)
HSEC_MII0_TXD1: J15.132 U88.35(C3)
HSEC_MII0_TXD2: J15.133 U88.33(C4)
HSEC_MII0_TXD3: J15.134 U88.31(C5)
HSEC_MII0_TXEN: J15.130 U88.42(C0)
HSEC_MII1_COL: J15.138 U89.24(C8)
HSEC_MII1_CRS(RES0_PWMOUT0): J15.139 U73.10(3B2) U89.22(C9)
HSEC_MII1_RXCLK: J15.141 U89.28(C6)
HSEC_MII1_RXD0: J15.143 U89.42(C0)
HSEC_MII1_RXD1: J15.144 U89.40(C1)
HSEC_MII1_RXD2: J15.145 U89.37(C2)
HSEC_MII1_RXD3: J15.146 U89.35(C3)
HSEC_MII1_RXDV: J15.142 U89.33(C4)
HSEC_MII1_RXER: J15.137 U89.31(C5)
HSEC_MII1_RXLINK: J15.140 U89.26(C7)
HSEC_MII1_TXCLK: J15.147 U88.18(C11)
HSEC_MII1_TXD0: J15.149 U88.28(C6)
HSEC_MII1_TXD1: J15.150 U88.26(C7)
HSEC_MII1_TXD2: J15.151 U88.24(C8)
HSEC_MII1_TXD3: J15.152 U88.22(C9)
HSEC_MII1_TXEN: J15.148 U88.20(C10)
HSEC_MMC0_CLK: J15.163 RA3.4
HSEC_MMC0_CMD: J15.164 RA5.3
HSEC_MMC0_D0: J15.165 RA3.3
HSEC_MMC0_D1: J15.166 RA3.2
HSEC_MMC0_D2: J15.167 RA3.1
HSEC_MMC0_D3: J15.168 RA5.4
HSEC_MMC0_SDCD: J15.170 RA5.2
HSEC_MMC0_WP: J15.169 RA5.1
HSEC_SDFM0_CLK0: J15.72 U1.B16(SDFM0_CLK0)
HSEC_SDFM0_CLK1: J15.101 R422.2 U1.A16(SDFM0_CLK1)
HSEC_SDFM0_CLK2: J15.105 U1.B15(SDFM0_CLK2)
HSEC_SDFM0_CLK3: J15.109 U1.A15(SDFM0_CLK3)
HSEC_SDFM0_D0: J15.91 U1.D14(SDFM0_D0)
HSEC_SDFM0_D1: J15.99 R421.2 U1.D13(SDFM0_D1)
HSEC_SDFM0_D2: J15.103 U1.C13(SDFM0_D2)
HSEC_SDFM0_D3: J15.107 U1.C14(SDFM0_D3)
HSEC_SPI0_CLK: J15.71 R139.1 R150.1
HSEC_SPI0_CS0: J15.73 U1.C11(SPI0_CS0)
HSEC_SPI0_D0: J15.67 R151.1 U1.C10(SPI0_D0)
HSEC_SPI0_D1: J15.69 U1.B11(SPI0_D1)
HSEC_SPI1_CLK: J15.79 U8.3(1B2)
HSEC_SPI1_CS0: J15.81 U8.13(4B2)
HSEC_SPI1_D0: J15.75 U8.6(2B2)
HSEC_SPI1_D1: J15.77 U8.10(3B2)
HSEC_TCK: J15.5 R183.2 U30.14(4B1)
HSEC_TDI: J15.8 R181.2 U30.5(2B1)
HSEC_TDO: J15.6 R180.2 U30.2(1B1)
HSEC_TMS: J15.3 R182.2 U30.11(3B1)
HSEC_UART1_RXD: J15.76 U44.3(1B2)
HSEC_UART1_TXD: J15.78 U44.6(2B2)
HSEC_VREF_3V3: J15.45 R417.1
I2C0_MUX_OE#: R165.1 U26.15(O\E\)
I2C0_MUX_SEL: R162.2 R164.1 U26.1(S) U60.10(P11)
I2C0_SCL: J8.40 R154.2 U26.2(1B1) U28.6(SCL)
I2C0_SDA: J8.42 R155.2 U26.5(2B1) U28.5(SDA)
ICSSM0_MUX_SEL: R1383.2 SW14.1 U60.21(P24) U87.9(SEL1) U87.10(SEL2) U88.9(SEL1)
ICSSM1_ETH_LED2: J7.12 Q6.3(D)
ICSSM1_INTN: R195.2 R214.2 U35.44(INT_N/PWDN_N)
ICSSM1_LED_GREEN: J7.13 Q7.3(D) R218.2
ICSSM1_LED_YELLOW: J7.14 Q8.3(D) R219.2
ICSSM1_MUX_EN1: R1381.1 U87.8(EN)
ICSSM1_MUX_EN2: R3861.2 U88.8(EN)
ICSSM1_MUX_EN3: R3864.1 U89.8(EN)
ICSSM1_MUX_SEL: R3873.2 SW16.1 U60.3(P02) U88.10(SEL2) U89.9(SEL1) U89.10(SEL2)
ICSSM1_RESETN: R220.2 U35.43(RESET_N) U36.4(Y)
ICSSM2_MUX_EN1: R3843.1 U82.8(EN)
ICSSM2_MUX_EN2: R3852.1 U85.8(EN)
ICSSM2_MUX_EN3: R3849.1 U84.8(EN)
ICSSM2_MUX_SEL: R3844.2 SW15.1 U60.4(P03) U82.9(SEL1) U82.10(SEL2) U84.9(SEL1) U84.10(SEL2) U85.9(SEL1) U85.10(SEL2)
ICSSM2_PWDN/INTN: J8.10 R191.2 R267.1
ICSSM2_RESETN: J8.12 R266.2 U39.4(Y)
ICSSM_BRD_CONN_DET: J8.36 R263.1
ICSSM_INH: J8.26 R264.2
ICSSM_MII0/MII1_COL_ADD: J8.14 R509.2 R517.2
ICSSM_MII0/MII1_COL_ON: R493.2 R501.2 TP83.1(TP)
ICSSM_MII0/MII1_CRS_ADD: J8.30 R510.2 R518.2
ICSSM_MII0/MII1_CRS_ON: R494.2 R502.2 TP84.1(TP)
ICSSM_MII0/MII1_RXCLK_ADD: J8.19 R531.2 R539.2
ICSSM_MII0/MII1_RXCLK_ON: R212.1 R483.2 R491.2
ICSSM_MII0/MII1_RXD0_ADD: J8.23 R525.2 R533.2
ICSSM_MII0/MII1_RXD0_ON: R225.2 R237.1 R476.2 R485.2 U35.33(RX_D0)
ICSSM_MII0/MII1_RXD1_ADD: J8.25 R526.2 R534.2
ICSSM_MII0/MII1_RXD1_ON: R226.2 R238.1 R477.2 R486.2 U35.34(RX_D1)
ICSSM_MII0/MII1_RXD2_ADD: J8.27 R527.2 R535.2
ICSSM_MII0/MII1_RXD2_ON: R231.1 R243.2 R479.2 R487.2 U35.35(RX_D2)
ICSSM_MII0/MII1_RXD3_ADD: J8.29 R528.2 R536.2
ICSSM_MII0/MII1_RXD3_ON: R232.1 R244.2 R480.2 R488.2 U35.36(RX_D3)
ICSSM_MII0/MII1_RXDV_ADD: J8.45 R529.2 R537.2
ICSSM_MII0/MII1_RXDV_ON: R230.1 R242.1 R481.2 R489.2 U35.38(RX_CTRL/RX_DV)
ICSSM_MII0/MII1_RXER_ADD: J8.39 R530.2 R538.2
ICSSM_MII0/MII1_RXER_ON: R213.2 R223.1 R228.2 R240.1 R482.2 R490.2
ICSSM_MII0/MII1_RXLINK_ADD: J8.43 R532.2 R540.2
ICSSM_MII0/MII1_RXLINK_ON: R222.1 R227.2 R239.1 R484.2 R492.2 U35.47(LED_0)
ICSSM_MII0/MII1_TXCLK_ADD: J8.3 R512.2 R520.2
ICSSM_MII0/MII1_TXCLK_ON: R210.1 R496.2 R504.2
ICSSM_MII0/MII1_TXD0_ADD: J8.7 R513.2 R521.2
ICSSM_MII0/MII1_TXD0_ON: R497.2 R505.2 U35.28(TX_D0)
ICSSM_MII0/MII1_TXD1_ADD: J8.9 R514.2 R522.2
ICSSM_MII0/MII1_TXD1_ON: R498.2 R506.2 U35.27(TX_D1)
ICSSM_MII0/MII1_TXD2_ADD: J8.11 R515.2 R523.2
ICSSM_MII0/MII1_TXD2_ON: R499.2 R507.2 U35.26(TX_D2)
ICSSM_MII0/MII1_TXD3_ADD: J8.13 R516.2 R524.2
ICSSM_MII0/MII1_TXD3_ON: R500.2 R508.2 U35.25(TX_D3)
ICSSM_MII0/MII1_TXEN_ADD: J8.35 R511.2 R519.2
ICSSM_MII0/MII1_TXEN_ON: R495.2 R503.2 U35.37(TX_CTRL/TX_EN)
ICSSM_MII0_COL: U82.13(A8) U87.25(B8)
ICSSM_MII0_COL_ADD: R517.1 U82.24(C8)
ICSSM_MII0_COL_ON: R493.1 U82.25(B8)
ICSSM_MII0_CRS: U82.14(A9) U87.23(B9)
ICSSM_MII0_CRS_ADD: R518.1 U82.22(C9)
ICSSM_MII0_CRS_ON: R494.1 U82.23(B9)
ICSSM_MII0_RXCLK: U82.11(A6) U87.29(B6)
ICSSM_MII0_RXCLK_ADD: R539.1 U82.28(C6)
ICSSM_MII0_RXCLK_ON: R483.1 U82.29(B6)
ICSSM_MII0_RXD0: U82.2(A0) U87.41(B0)
ICSSM_MII0_RXD0_ADD: R533.1 U82.42(C0)
ICSSM_MII0_RXD0_ON: R476.1 U82.41(B0)
ICSSM_MII0_RXD1: U82.3(A1) U87.39(B1)
ICSSM_MII0_RXD1_ADD: R534.1 U82.40(C1)
ICSSM_MII0_RXD1_ON: R477.1 U82.39(B1)
ICSSM_MII0_RXD2: U82.4(A2) U87.38(B2)
ICSSM_MII0_RXD2_ADD: R535.1 U82.37(C2)
ICSSM_MII0_RXD2_ON: R479.1 U82.38(B2)
ICSSM_MII0_RXD3: U82.5(A3) U87.36(B3)
ICSSM_MII0_RXD3_ADD: R536.1 U82.35(C3)
ICSSM_MII0_RXD3_ON: R480.1 U82.36(B3)
ICSSM_MII0_RXDV: U82.6(A4) U87.34(B4)
ICSSM_MII0_RXDV_ADD: R537.1 U82.33(C4)
ICSSM_MII0_RXDV_ON: R481.1 U82.34(B4)
ICSSM_MII0_RXER: U82.7(A5) U87.32(B5)
ICSSM_MII0_RXER_ADD: R538.1 U82.31(C5)
ICSSM_MII0_RXER_ON: R482.1 U82.32(B5)
ICSSM_MII0_RXLINK: U82.12(A7) U87.27(B7)
ICSSM_MII0_RXLINK_ADD: R540.1 U82.26(C7)
ICSSM_MII0_RXLINK_ON: R484.1 U82.27(B7)
ICSSM_MII0_TXCLK: U85.3(A1) U88.39(B1)
ICSSM_MII0_TXCLK_ADD: R520.1 U85.40(C1)
ICSSM_MII0_TXCLK_ON: R496.1 U85.39(B1)
ICSSM_MII0_TXD0: U85.4(A2) U88.38(B2)
ICSSM_MII0_TXD0_ADD: R521.1 U85.37(C2)
ICSSM_MII0_TXD0_ON: R497.1 U85.38(B2)
ICSSM_MII0_TXD1: U85.5(A3) U88.36(B3)
ICSSM_MII0_TXD1_ADD: R522.1 U85.35(C3)
ICSSM_MII0_TXD1_ON: R498.1 U85.36(B3)
ICSSM_MII0_TXD2: U85.6(A4) U88.34(B4)
ICSSM_MII0_TXD2_ADD: R523.1 U85.33(C4)
ICSSM_MII0_TXD2_ON: R499.1 U85.34(B4)
ICSSM_MII0_TXD3: U85.7(A5) U88.32(B5)
ICSSM_MII0_TXD3_ADD: R524.1 U85.31(C5)
ICSSM_MII0_TXD3_ON: R500.1 U85.32(B5)
ICSSM_MII0_TXEN: U85.2(A0) U88.41(B0)
ICSSM_MII0_TXEN_ADD: R519.1 U85.42(C0)
ICSSM_MII0_TXEN_ON: R495.1 U85.41(B0)
ICSSM_MII1_COL: U84.4(A2) U89.25(B8)
ICSSM_MII1_COL_ADD: R509.1 U84.38(B2)
ICSSM_MII1_COL_ON: R501.1 U84.37(C2)
ICSSM_MII1_CRS: U84.5(A3) U89.23(B9)
ICSSM_MII1_CRS_ADD: R510.1 U84.36(B3)
ICSSM_MII1_CRS_ON: R502.1 U84.35(C3)
ICSSM_MII1_RXCLK: U84.2(A0) U89.29(B6)
ICSSM_MII1_RXCLK_ADD: R531.1 U84.41(B0)
ICSSM_MII1_RXCLK_ON: R491.1 U84.42(C0)
ICSSM_MII1_RXD0: U84.11(A6) U89.41(B0)
ICSSM_MII1_RXD0_ADD: R525.1 U84.29(B6)
ICSSM_MII1_RXD0_ON: R485.1 U84.28(C6)
ICSSM_MII1_RXD1: U84.12(A7) U89.39(B1)
ICSSM_MII1_RXD1_ADD: R526.1 U84.27(B7)
ICSSM_MII1_RXD1_ON: R486.1 U84.26(C7)
ICSSM_MII1_RXD2: U84.13(A8) U89.38(B2)
ICSSM_MII1_RXD2_ADD: R527.1 U84.25(B8)
ICSSM_MII1_RXD2_ON: R487.1 U84.24(C8)
ICSSM_MII1_RXD3: U84.14(A9) U89.36(B3)
ICSSM_MII1_RXD3_ADD: R528.1 U84.23(B9)
ICSSM_MII1_RXD3_ON: R488.1 U84.22(C9)
ICSSM_MII1_RXDV: U84.15(A10) U89.34(B4)
ICSSM_MII1_RXDV_ADD: R529.1 U84.21(B10)
ICSSM_MII1_RXDV_ON: R489.1 U84.20(C10)
ICSSM_MII1_RXER: U84.16(A11) U89.32(B5)
ICSSM_MII1_RXER_ADD: R530.1 U84.19(B11)
ICSSM_MII1_RXER_ON: R490.1 U84.18(C11)
ICSSM_MII1_RXLINK: U84.3(A1) U89.27(B7)
ICSSM_MII1_RXLINK_ADD: R532.1 U84.39(B1)
ICSSM_MII1_RXLINK_ON: R492.1 U84.40(C1)
ICSSM_MII1_TXCLK: R1399.1 U85.12(A7)
ICSSM_MII1_TXCLK_ADD: R512.1 U85.27(B7)
ICSSM_MII1_TXCLK_ON: R504.1 U85.26(C7)
ICSSM_MII1_TXD0: U85.13(A8) U88.29(B6)
ICSSM_MII1_TXD0_ADD: R513.1 U85.25(B8)
ICSSM_MII1_TXD0_ON: R505.1 U85.24(C8)
ICSSM_MII1_TXD1: U85.14(A9) U88.27(B7)
ICSSM_MII1_TXD1_ADD: R514.1 U85.23(B9)
ICSSM_MII1_TXD1_ON: R506.1 U85.22(C9)
ICSSM_MII1_TXD2: U85.15(A10) U88.25(B8)
ICSSM_MII1_TXD2_ADD: R515.1 U85.21(B10)
ICSSM_MII1_TXD2_ON: R507.1 U85.20(C10)
ICSSM_MII1_TXD3: U85.16(A11) U88.23(B9)
ICSSM_MII1_TXD3_ADD: R516.1 U85.19(B11)
ICSSM_MII1_TXD3_ON: R508.1 U85.18(C11)
ICSSM_MII1_TXEN: U85.11(A6) U88.21(B10)
ICSSM_MII1_TXEN_ADD: R511.1 U85.29(B6)
ICSSM_MII1_TXEN_ON: R503.1 U85.28(C6)
IO_EXP_INTN: R395.1 U60.32(I\N\T\)
JTAG_MUX1_OE#: C178.2 R189.1 U30.15(O\E\)
JTAG_MUX_SEL: R188.1 SW1.1 U30.1(S)
JTAG_TDO2/GPIO_1: R233.1 R245.1 U35.22(JTAG_TDO/GPIO_1)
LED2_2: R221.1 R229.2 R241.1 U35.45(LED_2/GPIO_0)
LIN2_RXD: U1.B8(LIN2_RXD) U20.4(1A)
LIN2_TXD: U1.A8(LIN2_TXD) U20.7(2A)
LIN_EN: R285.1 U45.2(EN)
LIN_MUX_OE#: R280.1 U44.15(O\E\)
LIN_MUX_SEL: R277.2 R279.1 U44.1(S) U60.14(P15)
LIN_UART1_RXD: R284.1 U44.2(1B1)
LIN_UART1_TXD: R283.1 U44.5(2B1)
LM3488_COMP: C22.1 C23.1 U5.2(COMP)
LM3488_DR: U5.6(DR) U6.4(GATE)
LM3488_FB: R21.1 R26.2 U5.3(FB)
LM3488_ISEN: R22.1 U5.1(ISEN)
MCAN1_STB: R466.2 U29.14(NSTB) U60.18(P21)
MCAN4_CAN_H: J5.1 R171.1 U29.13(CANH)
MCAN4_CAN_L: J5.3 R174.2 U29.12(CANL)
MCAN4_RX: R173.1 U33.2(1B1)
MCAN4_RX_R: R173.2 U29.4(RXD)
MCAN4_T: C176.1 R171.2 R174.1
MCAN4_TX: R172.2 U33.5(2B1)
MCAN4_TX_R: R172.1 U29.1(TXD)
MCAN_EN: R1647.2 U29.6(EN)
MDIO0_MDC: R436.2 U1.M17(GPIO42) U81.3(A1) U90.3(A1)
MDIO0_MDIO: R437.2 U1.N16(GPIO41) U81.7(B1) U90.7(B1)
MDIO/MDC_MUX_SEL1: R474.1 U60.19(P22) U81.1(SEL)
MDIO/MDC_MUX_SEL2: R3871.2 U60.20(P23) U90.1(SEL)
MMC0_CLK: R123.1 RA2.4
MMC0_CLK_R: J4.5(CLK) R123.2 R132.2 R134.1 U24.6(IO4)
MMC0_CMD: J4.3(CMD) R131.2 RA4.3 U24.3(IO3)
MMC0_DAT0: J4.7(DAT0) R127.2 RA2.3 U24.7(IO5)
MMC0_DAT1: J4.8(DAT1) R128.2 RA2.2 U24.8(IO6)
MMC0_DAT2: J4.1(DAT2) R129.2 RA2.1 U24.1(IO1)
MMC0_DAT3: J4.2(CD/DAT3) R130.2 RA4.4 U24.2(IO2)
MMC0_SDCD: J4.9(CD1) R133.2 RA4.2 U25.5(IO2)
MMC0_WP: R124.1 RA4.1 TP48.1(TP)
MUX_UART1/LIN_RXD: R143.2 U44.4(1A)
MUX_UART1/LIN_TXD: R145.2 U44.7(2A)
OPSI_DQS: R111.1 R112.1 R113.1 R114.1 TP47.1(TP) U19.C3(DQS)
OSC0: C269.2 U52.88(OSC0) Y2.1
OSC1: C270.2 U52.89(OSC1) Y2.3
OSC_CLK_OUT: R273.1 U42.3(OUTPUT)
OSPI0_RESET_OUT0: R120.1 R194.2 U21.1(A)
OSPI/QSPI_MUX_SEL: R1679.1 R3836.1 U1.P16(GPIO37) U80.9(SEL1) U80.10(SEL2)
OSPI_(W#): R95.2 R3882.2 U1.L1(OSPI0_D5)
OSPI_CLK: R110.1 TP32.1(TP) U19.B2(C) U80.42(C0)
OSPI_CS0: R98.1 R109.2 TP45.1(TP) U19.C2(S#)
OSPI_DQ0: R100.1 R451.2 TP37.1(TP) U80.40(C1)
OSPI_DQ1: R101.1 R452.2 TP39.1(TP) U80.37(C2)
OSPI_DQ2: R102.2 R453.2 TP38.1(TP) U80.35(C3)
OSPI_DQ3: R103.1 R454.2 TP40.1(TP) U80.33(C4)
OSPI_DQ4: R104.1 R455.2 TP41.1(TP) U80.28(C6)
OSPI_DQ5: R105.1 R456.2 TP42.1(TP) U80.26(C7)
OSPI_DQ6: R106.1 R457.2 TP43.1(TP) U80.24(C8)
OSPI_DQ7: R107.1 R458.2 TP44.1(TP) U80.22(C9)
OSPI_DQS_SOC: R112.2 U80.20(C10)
OSPI_ERR#: R108.1 R3865.2 U19.A5(ERR#)
OSPI_LBCLK: R114.2 U80.18(C11)
OSPI_RSTN: R121.1 U19.A4(RESET#) U21.4(Y)
OSPI_RSTN_R: Q21.3(D) R3878.1 R3879.2
PMIC_COMP1_IN+: J15.175 U7.21(GPI2)
PMIC_COMP1_IN-: J15.177 U7.24(GPI3)
PMIC_COMP2_IN+: J15.171 U7.28(GPI5)
PMIC_COMP2_IN-: J15.173 U7.25(GPI4)
PMIC_DIAG_OUT: U1.V4(ADC4_AIN2) U7.32(DIAG_OUT)
PMIC_EN_OUT: R51.1 U7.17(EN_OUT)
PMIC_INTN: U1.R17(GPIO29) U7.22(GPO1)
PMIC_NRST: R432.1 U7.13(NRST)
PMIC_SAFE_OUT1: J15.113 R32.1
PMIC_SAFE_OUT2: J15.178 Q5.1(G) R202.1 U7.27(GPO4)
PMIC_SPI1_CLK: R41.2 TP18.1(TP) U7.33(SCLK) U8.2(1B1)
PMIC_SPI1_CS0: R39.2 TP16.1(TP) U7.36(NCS) U8.14(4B1)
PMIC_SPI1_D0: R40.2 TP17.1(TP) U7.35(SDI) U8.5(2B1)
PMIC_SPI1_D1: R38.2 R142.2 U8.11(3B1)
PMIC_WKUP1: J15.114 R34.2 U7.6(WAKE1)
PMIC_WKUP2: J15.172 J22.1 U7.43(WAKE2)
PORZ: Q21.1(G) R187.1 R327.1 R419.1 TP75.1(TP) U1.R2(PORZ) U21.2(B) U36.2(B) U39.2(B) U79.4(Y)
PORZ_RST: R427.2 U76.7(1Y) U78.3(B)
PORZ_VMAIN: U78.4(Y) U79.1(A)
PR0_IEP0_EDC_SYNC_OUT0: J16.1 R420.1
PR0_IEP0_EDC_SYNC_OUT1: J18.1 R422.1
PR0_IEP0_EDIO_DATA_IN_OUT30: J17.1 R421.1
PR0_IEP0_EDIO_DATA_IN_OUT31: J19.1 R423.1
PR0_MDIO0_MDC: R211.2 R470.2 U81.2(A0) U90.2(A0)
PR0_MDIO0_MDC_ADD: J8.20 R3867.2 U90.4(A)
PR0_MDIO0_MDC_ON: R472.2 U35.42(MDC) U81.4(A)
PR0_MDIO0_MDIO: R208.2 R471.2 U81.8(B0) U90.8(B0)
PR0_MDIO0_MDIO_ADD: J8.22 R3866.2 U90.6(B)
PR0_MDIO0_MDIO_ON: R473.2 U35.41(MDIO) U81.6(B)
PR0_PRU0_GPIO0: U1.K17(PR0_PRU0_GPIO0) U87.2(A0)
PR0_PRU0_GPIO1: U1.K18(PR0_PRU0_GPIO1) U87.3(A1)
PR0_PRU0_GPIO2: U1.J18(PR0_PRU0_GPIO2) U87.4(A2)
PR0_PRU0_GPIO3: U1.J17(PR0_PRU0_GPIO3) U87.5(A3)
PR0_PRU0_GPIO4: U1.K16(PR0_PRU0_GPIO4) U87.6(A4)
PR0_PRU0_GPIO5: U1.G17(PR0_PRU0_GPIO5) U87.7(A5)
PR0_PRU0_GPIO6: U1.K15(PR0_PRU0_GPIO6) U87.11(A6)
PR0_PRU0_GPIO8: U1.G15(PR0_PRU0_GPIO8) U87.12(A7)
PR0_PRU0_GPIO9: U1.F17(PR0_PRU0_GPIO9) U87.13(A8)
PR0_PRU0_GPIO10: U1.G18(PR0_PRU0_GPIO10) U87.14(A9)
PR0_PRU0_GPIO11: U1.M16(PR0_PRU0_GPIO11) U88.4(A2)
PR0_PRU0_GPIO12: U1.M15(PR0_PRU0_GPIO12) U88.5(A3)
PR0_PRU0_GPIO13: U1.H17(PR0_PRU0_GPIO13) U88.6(A4)
PR0_PRU0_GPIO14: U1.H16(PR0_PRU0_GPIO14) U88.7(A5)
PR0_PRU0_GPIO15: U1.L16(PR0_PRU0_GPIO15) U88.2(A0)
PR0_PRU0_GPIO16: U1.H18(PR0_PRU0_GPIO16) U88.3(A1)
PR0_PRU0_REF_CLK: R272.2 U35.20(XI)
PR0_PRU1_GPIO0: R247.2 U89.2(A0)
PR0_PRU1_GPIO1: R248.2 U89.3(A1)
PR0_PRU1_GPIO2: R249.2 U89.4(A2)
PR0_PRU1_GPIO3: R250.2 U89.5(A3)
PR0_PRU1_GPIO4: R251.2 U89.6(A4)
PR0_PRU1_GPIO5: R252.2 U89.7(A5)
PR0_PRU1_GPIO6: R253.2 U89.11(A6)
PR0_PRU1_GPIO8: R254.2 U89.12(A7)
PR0_PRU1_GPIO9: R255.2 U89.13(A8)
PR0_PRU1_GPIO10: R256.2 U89.14(A9)
PR0_PRU1_GPIO11: R257.2 U88.11(A6)
PR0_PRU1_GPIO12: R258.2 U88.12(A7)
PR0_PRU1_GPIO13: R259.2 U88.13(A8)
PR0_PRU1_GPIO14: R260.2 U88.14(A9)
PR0_PRU1_GPIO15: R261.2 U88.15(A10)
PR0_PRU1_GPIO16: R262.2 U88.16(A11)
PR0_PRU1_GPIO18: J15.70 R423.2 R1652.2
PR0_PRU1_GPIO19: J15.68 R420.2 R1653.2
PR0_PRU1_REF_CLK: J8.28 R274.2
QSPI_CLK: R89.1 TP31.1(TP) U18.6(CLK) U80.41(B0)
QSPI_CS1: R86.2 R99.1 TP46.1(TP) U18.1(C\S\)
QSPI_D0: R439.2 R1667.1 TP33.1(TP) U80.39(B1)
QSPI_D1: R440.2 R1668.1 TP34.1(TP) U80.38(B2)
QSPI_D2: R84.2 R441.2 TP35.1(TP) U80.36(B3)
QSPI_D3: R85.2 R442.2 TP36.1(TP) U80.34(B4)
R_LED2_0: J7.11 R216.1
RBIAS2: R215.1 TP63.1(TP) U35.12(RBIAS)
RESETZ: R185.1 R428.2 U76.2(3Y)
RESETZ_HSEC: J15.120 R419.2
RJ45_ETH0_D0_N: J7.10(MX0-) U35.2(TD_M_A)
RJ45_ETH0_D0_P: J7.9(MX0+) U35.1(TD_P_A)
RJ45_ETH0_D1_N: J7.8(MX1-) U35.5(TD_M_B)
RJ45_ETH0_D1_P: J7.7(MX1+) U35.4(TD_P_B)
RJ45_ETH0_D2_N: J7.6(MX2-) U35.8(TD_M_C)
RJ45_ETH0_D2_P: J7.5(MX2+) U35.7(TD_P_C)
RJ45_ETH0_D3_N: J7.4(MX3-) U35.11(TD_M_D)
RJ45_ETH0_D3_P: J7.3(MX3+) U35.10(TD_P_D)
RSVD_T4: R82.1 U1.T4(RSVD_T4)
RSVD_U1: R186.1 U1.U1(RSVD_U1)
RSVD_U3: TP59.1(TP) U1.U3(RSVD_U3)
RSVD_V2: TP60.1(TP) U1.V2(RSVD_V2)
SAFETY_ERRORN: Q20.1(G) R435.2 TP56.1(TP) U1.D4(SAFETY_ERRORN)
SOC_BOOTMODE0: R119.2 U48.15(1B1)
SOC_BOOTMODE1: R122.2 U48.14(1B2)
SOC_BOOTMODE2: R150.2 U48.13(2B1)
SOC_BOOTMODE3: R151.2 U48.12(2B2)
SOC_CLK_IN: R176.1 U43.4(Y)
SOC_CLK_XTAL_IN: C184.1 R178.1 Y1.1
SOC_CLK_XTAL_OUT: C185.1 R179.1 Y1.3
SOC_I2C0_SCL: R135.1 R159.2 U26.4(1A)
SOC_I2C0_SDA: R136.1 R158.2 U26.7(2A)
SOC_I2C2_SCL: R156.2 U1.C7(UART0_RTSN) U12.5(SCL) U13.5(SCL) U27.8(SCL) U46.3(SCL1) U59.15(SCL) U60.29(SCL)
SOC_I2C2_SDA: R157.2 U1.B7(UART0_CTSN) U12.4(SDA) U13.4(SDA) U27.7(SDA) U46.2(SDA1) U59.2(SDA) U60.30(SDA)
SOC_INTN: U20.2(1B1) U76.5(2Y)
SOC_MMC0_CLK: RA2.5 RA3.5 TP49.1(TP) U1.B6(MMC0_CLK)
SOC_MMC0_CMD: RA4.6 RA5.6 U1.A4(MMC0_CMD)
SOC_MMC0_DAT0: RA2.6 RA3.6 U1.B5(MMC0_D0)
SOC_MMC0_DAT1: RA2.7 RA3.7 U1.B4(MMC0_D1)
SOC_MMC0_DAT2: RA2.8 RA3.8 U1.A3(MMC0_D2)
SOC_MMC0_DAT3: RA4.5 RA5.5 U1.A2(MMC0_D3)
SOC_MMC0_SDCD: RA4.7 RA5.7 U1.A5(MMC0_CD)
SOC_MMC0_WP: RA4.8 RA5.8 U1.C6(MMC0_WP)
SOC_OSPI0_CLK: R87.1 U80.2(A0)
SOC_OSPI0_CSN0: R98.2 U1.P1(OSPI0_CSN0)
SOC_OSPI0_CSN1: R99.2 U1.R3(OSPI0_CSN1)
SOC_OSPI0_D0: R90.1 R119.1 U80.3(A1)
SOC_OSPI0_D1: R91.1 R122.1 U80.4(A2)
SOC_OSPI0_D2: R92.1 U80.5(A3)
SOC_OSPI0_D3: R93.1 U80.6(A4)
SOC_OSPI0_D4: R94.1 U80.11(A6)
SOC_OSPI0_D5: R95.1 U80.12(A7)
SOC_OSPI0_D6: R96.1 U80.13(A8)
SOC_OSPI0_D7: R97.1 U80.14(A9)
SOC_OSPI0_DQS: R118.1 U80.15(A10)
SOC_OSPI0_LBCLK: R117.1 U80.16(A11)
SOC_SPI1_CLK: R43.2 R140.1 U8.4(1A)
SOC_SPI1_CS0: R46.2 R144.1 U8.12(4A)
SOC_SPI1_D0: R44.2 R141.1 U8.7(2A)
SOC_SPI1_D1: R45.2 U1.D9(SPI1_D1) U8.9(3A)
SOC_TA_I2C2_SCL: R302.1 R310.2
SOC_TA_I2C2_SDA: R304.1 R311.2
SOC_TCK: TP52.1(TP) U1.B3(TCK) U30.12(4A)
SOC_TDI: TP53.1(TP) U1.C5(TDI) U30.7(2A)
SOC_TDO: R177.1 TP54.1(TP) U30.4(1A)
SOC_TDO_R: R177.2 U1.C4(TDO)
SOC_TMS: TP55.1(TP) U1.D5(TMS) U30.9(3A)
SOC_XDS_I2C2_SCL: R312.2 U52.82(PL1)
SOC_XDS_I2C2_SDA: R313.2 U52.81(PL0)
SPI1_MUX_OE#: R50.1 U8.15(O\E\)
SPI1_MUX_SEL: R49.1 U8.1(S) U60.11(P12)
SW_PB_INTN: Q10.2(S) SW11.2 U76.3(2A)
SW_PB_PORZ: Q9.2(S) SW10.2 U76.1(1A)
SW_PB_RESETZ: Q11.2(S) SW12.2 U76.6(3A)
SYS_BOOTMODE0: R323.2 SW6.1 U47.2(P0) U48.6(1A1)
SYS_BOOTMODE1: R324.2 SW6.2 U47.3(P1) U48.7(1A2)
SYS_BOOTMODE2: R325.2 SW6.3 U47.4(P2) U48.8(2A1)
SYS_BOOTMODE3: R326.2 SW6.4 U47.5(P3) U48.9(2A2)
SYSBOOT_BUF_ENZ: R328.1 U49.2(B)
TA_GPIO1: Q10.1(G) R291.1 R298.1 R371.2
TA_GPIO1_XDS: R365.2 U52.74(PM4) U57.2(INA)
TA_GPIO2: R290.1 R299.1 R378.2
TA_GPIO2_XDS: R377.2 U52.73(PM5) U58.2(INA)
TA_GPIO3: J12.1 R289.1 R300.1 R372.2 U49.1(A)
TA_GPIO3_XDS: R366.2 U52.72(PM6) U57.3(INB)
TA_GPIO4: R288.1 R301.1 R373.2 U47.1(R\E\S\E\T\)
TA_GPIO4_XDS: R367.2 U52.71(PM7) U57.4(INC)
TA_PORZN: Q9.1(G) R293.1 R296.1 R374.2
TA_PORZN_XDS: R368.2 U52.77(PM1) U57.5(IND)
TA_POWERDOWNZ: Q12.1(G) R295.1 R376.2 R468.1
TA_POWERDOWNZ_XDS: R370.2 U52.78(PM0) U57.7(INF)
TA_RESETZ: Q11.1(G) R292.1 R297.1 R375.2
TA_RESETZ_XDS: R369.2 U52.76(PM2) U57.6(INE)
TCAN_WAKE: R31.2 U29.9(WAKE)
TM4C129_RST#: R353.2 R355.1 TP73.1(TP) U52.70(R\S\T\)
TM4C129_TCK: TP68.1(TP) U52.100(PC0/TCK/SWCLK)
TM4C129_TDI: TP70.1(TP) U52.98(PC2/TDI)
TM4C129_TDO: TP71.1(TP) U52.97(PC3/TDO/SWO)
TM4C129_TMS: TP69.1(TP) U52.99(PC1/TMS/SWDIO)
TMP411_ALERT: R160.2 U27.6(A\L\E\R\T\/T\H\E\R\M\2\)
TMP411_THERM: R161.2 U27.4(T\H\E\R\M\)
TPS2121_CP2: R11.2 R15.1 U4.3(CP2)
TPS2121_OV1: R12.2 R16.1 U4.5(OV1)
TPS2121_OV2: R10.2 R14.1 U4.4(OV2)
TPS2121_PR1: R13.2 R17.1 U4.6(PR1)
TPS2296_EN: LD1.1(CATHODE) U2.4(Y) U3.3(ON)
TUSB_OUT1: R4.2 U2.2(B) U17.7(SDA/OUT1)
TUSB_OUT2: R3.2 U2.1(A) U17.8(SCL/OUT2)
UART0_RXD: R344.1 U1.A7(UART0_RXD)
UART0_TXD: U1.A6(UART0_TXD) U54.3(INB)
UART2_MUX_SEL: R62.2 R67.1 U20.1(S) U60.12(P13)
UART2_RXD_HSEC: J15.161 U20.3(1B2)
UART2_TXD_HSEC: J15.162 U20.6(2B2)
USB_XDS110_ID: J13.4(ID) R338.2 U53.4(IO3)
USBC_EARTH: C6.2 J1.SH1 J1.SH2 J1.SH3 J1.SH4 R9.2
USD_LS_EN: U22.4(Y) U23.3(ON)
USER_LED0: R146.2 U20.5(2B1)
USER_LED1: R147.2 R3877.2
VLIN: C236.1 D6.2(A) J10.1 SW4.2(COM) U45.7(VSUP)
VMAIN: C10.1 C11.1 C12.2 C17.1 C18.1 C19.1 C83.1 C93.1 L1.1 R47.1 R57.1 R137.1 R138.1 R201.1 R433.1 TP80.1(TP) U4.1(OUT1) U4.8(OUT2) U5.8(VIN) U10.2(VIN) U14.7(PVIN) U14.8(AVIN)
VMAIN_12V0: C20.1 C21.1 C348.2 C353.1 C354.1 D4.1(CATHODE) J20.2 Q13.5(S) R20.2 R21.2 R175.1 TP79.1(TP) U29.10(VSUP)
VMAIN_MON: R433.2 R434.1 U79.2(B)
VMAINP_12V0: C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C50.1 C51.1 C52.1 C53.1 C54.1 C355.1 Q13.1(D1) Q13.2(D2) Q13.3(D3) TP3.1(TP) U7.7(VBATP1) U7.8(VBATP2) U7.9(VBATS)
VPP_1V7: C346.1 C347.1 R63.1 R83.1 R463.1 TP76.1(TP) U66.1(OUT)
VPP_LDO_EN: R465.1 U60.13(P14) U66.4(EN)
VPP_R: C101.1 R83.2 R467.2 TP86.1(TP) U1.N3(VPP)
VREG: C62.1 TP7.1(TP) U7.40(VREG_OUT)
VREG_1P8_OUT: C61.1 TP8.1(TP) U7.39(VREG_1P8_OUT)
VSYS_1V2: C81.1 L4.2 R52.1 R53.1 R75.3 TP82.1(TP) U9.3(VOS)
VSYS_1V2_EN: R51.2 R430.2 U9.5(EN)
VSYS_1V2_FB: R52.2 R56.2 U9.9(FB/VSET)
VSYS_1V2_PG: R59.2 R76.2 U9.1(PG) U78.1(A)
VSYS_1V2_SW: L4.1 U9.2(SW)
VSYS_1V7_FB: R463.2 R464.1 U66.2(FB)
VSYS_3V3_LDO1: C58.1 C59.1 C60.1 C73.1 C86.1 C98.1 C157.1 C158.1 C159.2 C160.1 C161.1 C162.1 C163.1 C164.2 C166.1 C171.1 C173.1 C175.2 C177.1 C178.1 C179.2 C181.2 C187.2 C189.1 C222.1 C230.1 C233.1 C240.1 C243.1 C265.1 C277.1 C278.1 C335.1 C340.1 C341.1 C356.1 C357.1 C358.1 C359.1 C360.1 C361.1 C362.1 C363.1 C364.1 C365.1 C366.1 C367.1 C368.1 C369.1 C370.1 C371.1 C372.1 C373.1 C374.1 C3743.1 C3744.1 C3745.1 C3746.1 FL6.1 FL7.1 J6.10 J15.119 R38.1 R39.1 R40.1 R41.1 R43.1 R44.1 R45.1 R46.1 R48.1 R59.1 R62.1 R74.3 R78.2 R80.1 R84.1 R85.1 R86.1 R100.2 R101.2 R102.1 R103.2 R104.2 R105.2 R106.2 R107.2 R108.2 R109.1 R111.2 R120.2 R121.2 R152.1 R153.1 R154.1 R155.1 R156.1 R157.1 R158.1 R159.1 R162.1 R167.1 R180.1 R181.1 R182.1 R183.1 R184.1 R200.1 R214.1 R217.2 R263.2 R265.2 R267.2 R276.2 R392.2 R395.2 R425.1 R426.1 R427.1 R428.1 R429.1 R430.1 R431.1 R436.1 R437.1 R466.1 R470.1 R471.1 R472.1 R473.1 R474.2 R1381.2 R1647.1 R1667.2 R1668.2 R1678.2 R1679.2 R3832.1 R3842.1 R3843.2 R3849.2 R3852.2 R3858.1 R3861.1 R3864.2 R3866.1 R3867.1 R3872.1 R3878.2 R3882.1 TP6.1(TP) U7.37(VDDIO) U7.38(LDO1_OUT) U8.16(VCC) U16.1(VIN) U18.8(VCC) U19.B4(VCC) U19.D1(VCCQ#D1) U19.E4(VCCQ#E4) U20.16(VCC) U21.5(VCC) U26.16(VCC) U28.8(VCC) U29.5(VIO) U30.16(VCC) U31.8(VCC2) U32.1(VCC1) U36.5(VCC) U39.5(VCC) U42.1(ENABLE/DISABLE) U42.4(VDD) U46.1(VCC1) U48.2(VCCB) U54.1(VCC1) U60.27(VCCP) U60.31(VCC) U76.8(VCC) U78.5(VCC) U79.5(VCC) U80.1(VCC#1) U80.17(VCC#17) U80.30(VCC#30) U81.10(VCC) U82.1(VCC#1) U82.17(VCC#17) U82.30(VCC#30) U84.1(VCC#1) U84.17(VCC#17) U84.30(VCC#30) U85.1(VCC#1) U85.17(VCC#17) U85.30(VCC#30) U87.1(VCC#1) U87.17(VCC#17) U87.30(VCC#30) U88.1(VCC#1) U88.17(VCC#17) U88.30(VCC#30) U89.1(VCC#1) U89.17(VCC#17) U89.30(VCC#30) U90.10(VCC)
VSYS_3V3_LDO2: C64.1 C65.1 C66.1 C89.1 C90.1 C167.1 C168.1 C172.2 C188.1 C234.1 C276.1 R124.2 R125.2 R127.1 R128.1 R129.1 R130.1 R131.1 R132.1 R133.1 R160.1 R161.1 R204.1 R277.1 R282.1 R285.2 R3835.1 TP10.1(TP) U7.11(LDO2_OUT) U12.6(VS) U13.2(A0) U13.6(VS) U22.5(VCC) U23.1(VIN) U24.10(VCC) U27.1(V+) U33.16(VCC) U44.16(VCC) U59.1(VCC)
VSYS_MON: C186.2 R201.2 R203.1 TP57.1(TP) U1.U2(VSYS_MON)
VSYS_TA_3V3: C84.1 C85.1 C238.1 C239.1 C241.1 C242.1 C244.1 C245.2 C246.2 C272.2 C275.1 C351.2 J11.1 J11.2 J11.3 L5.2 R58.2 R72.1 R73.1 R286.1 R287.1 R288.2 R289.2 R290.2 R291.2 R292.2 R293.2 R307.2 R316.1 R317.1 R318.1 R319.1 R320.2 R321.2 R322.2 R468.2 TP21.1(TP) U10.8(SLEEP) U10.10(VOS) U47.14(VCCP) U47.15(VCCI) U48.3(VCCA) U49.5(VCC) U50.5(VCC) U56.8(VCC2) U57.16(VCC2) U58.8(VCC2)
VSYS_TA_3V3_EN: R57.2 U10.3(EN)
VSYS_TA_3V3_PG: R58.1 U10.7(PG)
VSYS_TA_3V3_SW: L5.1 U10.9(SW)
WARMRESETN: R126.1 R185.2 R394.1 TP58.1(TP) U1.C3(WARMRSTN)
WARMRESETN_R: R126.2 U22.1(A)
XDS110_EMU0: R357.2 U52.42(PF0)
XDS110_EMU1: R356.2 U52.43(PF1)
XDS110_PROG_STAZ1: R342.2 U52.4(PD3/AIN12)
XDS110_PROG_STAZ2: R343.1 U52.3(PD2/AIN13)
XDS110_TCK: U31.3(INB) U52.35(PA2/SSI0CLK)
XDS110_TCK_ISO: R198.1 U30.13(4B2)
XDS110_TDI: U32.7(INA) U52.38(PA5/SSI0XDAT1)
XDS110_TDI_ISO: R199.1 U30.6(2B2)
XDS110_TDO: U32.6(OUTB) U52.37(PA4/SSI0XDAT0)
XDS110_TDO_ISO: U30.3(1B2) U32.3(INB)
XDS110_TMS: U31.2(INA) U52.36(PA3/SSI0FSS)
XDS110_TMS_ISO: R197.1 U30.10(3B2)
XDS110_TRST#: R337.1 U52.40(PA6)
XDS110_UART0_RXD: U52.33(PA0/U0RX) U54.6(OUTB)
XDS110_UART0_TXD: R336.1 U54.7(INA)
XDS110_VBUS_DET: R340.2 R341.1 U52.1(PD0/AIN15)
XDS_GND: C180.1 C182.1 C183.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C266.2 C267.2 C268.2 C269.1 C270.1 C271.1 C273.1 C274.2 C352.2 J13.5(GND) LD9.1(CATHODE) LD10.1(CATHODE) R315.2 R333.2 R335.2 R337.2 R341.2 R349.1 R350.1 R351.1 R352.1 R355.2 R358.2 TP74.1(TP) U31.4(GND1) U32.5(GND2) U51.6(GND) U51.9(PAD) U52.10(GNDA) U52.17(GND#17) U52.48(GND#48) U52.55(GND#55) U52.58(GND#58) U52.64(W\A\K\E\) U52.66(XOSC0) U52.80(GND#80) U52.114(GND#114) U53.3(GND) U54.5(GND2) U55.1(ANODE) U56.4(GND1) U57.8(GND1) U58.3(INB) U58.4(GND1) Y2.2 Y2.4
XDS_RBIAS: R358.1 U52.59(RBAIS)
XDS_SHIELD: C263.1 J13.6(SH1) J13.7(SH2) J13.8(SH3) J13.9(SH4) J13.10(SH5) J13.11(SH6) R335.1
XDS_USB_D_N: J13.2(D-) U52.93(PL7/USB0DM) U53.1(IO1)
XDS_USB_D_P: J13.3(D+) U52.94(PL6/USB0DP) U53.2(IO2)
XDS_USB_ID: R338.1 U52.95(PB0/USB0ID)
XDS_VREF: C267.1 C268.1 R354.2 U52.9(VREFA+) U55.3(CATHODE)
XTAL_IN: R176.2 R178.2 U1.T1(XTAL_XI)
XTAL_OUT: R179.2 U1.R1(XTAL_XO)
N23200398: C264.1 R339.1 U52.96(PB1/USB0VBUS)
N23200423: R345.1 R349.2 U52.60(PK7)
N23200491: LD10.2(ANODE) R343.2
N23200507: R348.1 R352.2 U52.63(PK4)
N23200509: R346.1 R350.2 U52.61(PK6)
N23200516: R347.1 R351.2 U52.62(PK5)
N23200616: LD9.2(ANODE) R342.1
N31943874: R306.1 R307.1 R308.1 R309.1 U46.8(VCC2)
N32133653: R329.2 U49.4(Y)
N32133735: R319.2 SW6.5
N32133737: R318.2 SW6.6
N32133754: R317.2 SW6.7
N32133756: R316.2 SW6.8
N32302430: C336.1 R425.2 SW10.4
N32359377: C338.1 R429.2 SW12.4
N32360252: C337.1 R426.2 SW11.4
N32781982: R166.1 U26.9(3A) U26.12(4A)
N32800162: R321.1 U47.16(ADDR)
N32800169: R320.1 U47.11(I\N\T\)
N32801024: LD11.2(ANODE) R381.1
N32801040: LD12.2(ANODE) R382.1
N32801094: LD13.2(ANODE) R383.1
N32801104: LD14.2(ANODE) R384.1
N32801160: LD15.2(ANODE) R385.1
N32801170: LD16.2(ANODE) R386.1
N32801226: LD17.2(ANODE) R387.1
N32801236: LD18.2(ANODE) R388.1
N32801519: R389.2 U59.9(A0)
N32801526: R390.2 U59.10(A1)
N32801533: R391.2 U59.7(A2)
N32817219: R392.1 R393.2 U60.26(ADDR)
N32817226: R394.2 U60.28(R\E\S\E\T\)
N32843337: R184.2 SW1.2
N32845049: C231.1 C232.1 FL6.2 U41.6(VDD)
N32845083: R271.2 R273.2 U41.1(CLKIN)
N32845192: R272.1 U41.3(Y0)
N32845194: R274.1 U41.8(Y1)
N32845196: R275.1 U41.5(Y2)
N32845712: R396.1 U1.V9(ADC2_AIN4)
N32845714: R397.1 U1.T8(ADC2_AIN5)
N32851242: J12.2 R331.1
N32914108: R336.2 U52.34(PA1/U0TX)
N32995593: R77.1 R79.1 U14.4(FB)
N32995608: L6.1 U14.2(SW)
N32995634: C95.1 U14.9(SS/TR)
N33038314: LD3.2(ANODE) R48.2
N33056127: LD6.2(ANODE) R137.2
N33056129: LD6.1(CATHODE) Q3.3(D)
N33056157: Q3.1(G) R146.1 R148.1
N33200463: R139.2 U1.A11(SPI0_CLK)
N33200513: R140.2 U1.A10(SPI1_CLK)
N33221101: R400.1 U1.U4(ADC4_AIN5)
N33221125: R398.1 U1.U5(ADC4_AIN3)
N33221128: R399.1 U1.V3(ADC4_AIN4)
N33235493: R328.2 U50.4(Y)
N33277398: Q4.1(G) R147.1 R149.1
N33277404: LD7.2(ANODE) R138.2
N33277419: LD7.1(CATHODE) Q4.3(D)
N33334993: R163.1 U27.2(D+)
N33461336: J15.43 R416.1
N33514520: C247.1 R327.2 U50.2(A)
N33770351: R275.2 U43.2(A)
N33879615: R143.1 U1.A9(LIN1_RXD)
N33879618: R145.1 U1.B9(LIN1_TXD)
N33879812: R283.2 U45.4(TXD)
N33879815: R282.2 R284.2 U45.1(RXD)
N33880944: R281.1 U44.9(3A) U44.12(4A)
N33881371: C237.1 J10.2 SW5.1 U45.6(LIN)
N33882160: D6.1(K) R278.1
N33883080: R278.2 SW5.2
N33884757: R344.2 U54.2(OUTA)
N33885275: R199.2 U32.2(OUTA)
N33885316: R197.2 U31.7(OUTA)
N33885344: R198.2 U31.6(OUTB)
N33933588: R412.1 U74.9(S1B)
N33933633: R413.1 U74.7(S2B)
N33986982: C235.1 D7.1(K) SW4.3
N34075368: R163.2 U27.3(D-)
N34422674: R135.2 U1.A13(I2C0_SCL)
N34422702: R136.2 U1.B13(I2C0_SDA)
N34549994: R144.2 U1.C9(SPI1_CS0)
N34603287: R90.2 U1.N1(OSPI0_D0)
N34603290: R91.2 U1.N4(OSPI0_D1)
N34603328: R97.2 U1.K1(OSPI0_D7)
N34603356: R87.2 U1.N2(OSPI0_CLK)
N34603584: R92.2 U1.M4(OSPI0_D2)
N34603591: R93.2 U1.P3(OSPI0_D3)
N34660939: TP72.1(TP) U52.75(PM3)
N34662299: R361.1 U56.6(SCL2)
N34662301: R362.1 U56.7(SDA2)
N34663370: J11.27 R296.2
N34663404: J11.30 R298.2
N34663407: J11.31 R299.2
N34663410: J11.32 R300.2
N34663413: J11.28 R297.2
N34663434: J11.33 R301.2
N34665841: J11.36 R302.2
N34665844: J11.37 R303.2
N34665847: J11.38 R304.2
N34665853: J11.39 R305.2
N34666564: R309.2 R310.1 R312.1 U46.6(SCL2)
N34666567: R308.2 R311.1 R313.1 U46.7(SDA2)
N34733472: TP13.1(TP) U7.23(GPO2)
N34733475: TP15.1(TP) U7.26(GPO3)
N34733595: R32.2 U7.31(SAFE_OUT1)
N34755833: L3.1 R28.2 R29.1 U7.3(BB_SW1_1) U7.4(BB_SW1_2)
N34755845: C56.1 L3.2 U7.45(BB_SW2_1) U7.46(BB_SW2_2)
N34755854: C55.2 U7.5(BB_BST1)
N34755863: C56.2 U7.44(BB_BST2)
N34755869: C55.1 R28.1
N34756880: R36.1 U7.19(TRACK)
N34775734: C82.1 U9.8(SS/TR)
N34778760: TP61.1(TP) U35.13(VDDA1P8_1) U35.48(VDDA1P8_2)
N34779936: Q7.1(G) R222.2
N34780102: R207.1 R211.1 U1.L18(PR0_MDIO0_MDC)
N34780104: R208.1 R209.1 U1.L17(PR0_MDIO0_MDIO)
N34780660: FL3.2 J7.2(VCC)
N34780919: Q8.1(G) R223.2
N34780978: R210.2 U35.29(GTX_CLK/TX_CLK)
N34780980: R213.1 U35.46(LED_1/RX_ER)
N34780998: R212.2 U35.32(RX_CLK)
N34781014: Q6.1(G) R221.2
N34781978: R81.2 U15.3(EN)
N34798910: C99.1 U16.4(CT)
N34800889: R94.2 U1.M1(OSPI0_D4)
N34800895: R96.2 U1.L2(OSPI0_D6)
N34801624: R191.1 U1.K2(EPWM12_A)
N34801627: R192.1 U1.K4(EPWM13_A)
N34801685: R194.1 U1.J1(EPWM11_B)
N34801688: R195.1 U1.J4(EPWM12_B)
N34801691: R196.1 U1.K3(EPWM13_B)
N34820051: J11.26 R295.2
N34820524: Q5.2(S) R200.2
N34820530: LD8.2(ANODE) Q5.3(D)
N34828765: LD5.2(ANODE) R72.2
N34828799: LD4.2(ANODE) R73.2
N34828801: LD4.1(CATHODE) Q2.3(D)
N34828819: Q2.1(G) R76.1
N34830317: C92.1 R69.1 U12.10(IN+)
N34830329: C92.2 R71.1 U12.8(VBUS) U12.9(IN-)
N34830425: C91.1 R68.1 U13.10(IN+)
N34830437: C91.2 R70.1 U13.8(VBUS) U13.9(IN-)
N34869480: R431.2 R432.2 U78.6(C)
N34869775: C57.1 R29.2
N35052540: R7.1 U17.5(ADDR)
N35052638: R18.1 U4.10(ILM)
N35052879: C9.1 U3.6(CT)
N35052899: R6.2 U17.6(INT_N/OUT3)
N35052954: R2.2 U17.3(PORT)
N35052969: TP1.1(TP) U17.9(ID)
N35053013: R8.1 U17.11(EN_N)
N35053423: C16.1 U4.11(SS)
N35053522: D4.2(ANODE) L1.2 U6.5(D1)
N35053536: C24.1 R22.2 R27.1 U6.1(S1) U6.2(S2) U6.3(S3)
N35053695: R23.1 U5.7(FA/SYNC/SD)
N35053732: C23.2 R24.1
N35056553: LD1.2(ANODE) R1.2
N35059517: R141.2 U1.B10(SPI1_D0)
N35065419: R42.1 U7.12(GND)
N35071225: R435.1 U7.18(GPI1)
N35139843: R142.1 U7.34(SDO)
N35230144: R439.1 U18.5(DI/IO0)
N35230147: R440.1 U18.2(DO/IO1)
N35230153: R442.1 U18.7(H\O\L\D\/IO3)
N35244293: R452.1 U19.D2(DQ1)
N35244332: R453.1 U19.C4(DQ2/W#)
N35244360: R454.1 U19.D4(DQ3)
N35244387: R455.1 U19.D5(DQ4)
N35244414: R456.1 U19.E3(DQ5)
N35244441: R457.1 U19.E2(DQ6)
N35244468: R458.1 U19.E1(DQ7)
N35248046: R451.1 U19.D3(DQ0)
N35252647: R441.1 U18.3(W\P\/IO2)
N35271296: TP78.1(TP) U29.8(NFAULT)
N35329968: R117.2 U1.L3(UART1_RXD)
N35329989: R118.2 U1.M3(UART1_TXD)
N35342843: R371.1 U57.15(OUTA)
N35343433: R372.1 U57.14(OUTB)
N35343436: R373.1 U57.13(OUTC)
N35343439: R374.1 U57.12(OUTD)
N35343442: R375.1 U57.11(OUTE)
N35343445: R376.1 U57.10(OUTF)
N35345342: R378.1 U58.7(OUTA)
N35373997: R314.1 R315.1 U46.5(GND2)
N35375175: J20.1 R34.1
N35376496: J21.1 R31.1 R175.2
N35387120: R116.1 U29.7(INH)
N35387809: R1678.1 U80.8(EN)
N35395797: R461.1 U20.15(O\E\)
N35537520: Q13.4(G) R20.1 R469.1
N35538921: Q12.3(D) R469.2
N35654609: Q20.2(S) R3832.2
N35654631: LD19.2(ANODE) Q20.3(D)
N35656175: LD2.2(ANODE) R47.2
N35656498: LD20.2(ANODE) R3833.2
N35656998: LD21.2(ANODE) R3834.2
N35657235: LD22.2(ANODE) R3835.2
N35672996: R3842.2 SW15.2
N35712813: J22.2 R116.2
N35805242: R247.1 U1.F18(PR0_PRU1_GPIO0)
N35805430: R255.1 U1.C18(PR0_PRU1_GPIO9)
N35805533: R248.1 U1.G16(PR0_PRU1_GPIO1)
N35805539: R249.1 U1.E17(PR0_PRU1_GPIO2)
N35805550: R250.1 U1.E18(PR0_PRU1_GPIO3)
N35805561: R251.1 U1.F16(PR0_PRU1_GPIO4)
N35805574: R252.1 U1.F15(PR0_PRU1_GPIO5)
N35805586: R253.1 U1.E16(PR0_PRU1_GPIO6)
N35805597: R254.1 U1.D18(PR0_PRU1_GPIO8)
N35805610: R256.1 U1.D17(PR0_PRU1_GPIO10)
N35805636: R257.1 U1.B18(PR0_PRU1_GPIO11)
N35805639: R258.1 U1.B17(PR0_PRU1_GPIO12)
N35805644: R259.1 U1.D16(PR0_PRU1_GPIO13)
N35805649: R260.1 U1.C17(PR0_PRU1_GPIO14)
N35805656: R261.1 U1.A17(PR0_PRU1_GPIO15)
N35805662: R262.1 U1.C16(PR0_PRU1_GPIO16)
N35805667: R1652.1 U1.C15(PR0_PRU1_GPIO18)
N35805672: R1653.1 U1.D15(PR0_PRU1_GPIO19)
N35820709: R3858.2 SW14.2
N35821153: R1399.2 U88.19(B11)
N35824901: R475.2 U81.9(E\N\)
N35842882: R3870.2 U90.9(E\N\)
N35844058: R3872.2 SW16.2

Pads without a net: J1 A2 A3 A6 A7 A8 A10 A11 B2 B3 B6 B7 B8 B10 B11; J2 2; J3 2; J11 4 5 6 8 9 10 11 12 13 14 15 17 18 19 20 21 22 23 24 29 35; J15 1 2 4 41 44 66 88 115 116 136 155 156 159 160 174 176; SW9 1 4; SW13 1; U1 P15; U10 4; U12 3; U13 3; U14 10; U19 A2 A3 B1 B5 C5; U20 9 10 11 12 13 14; U23 4; U24 4 9; U25 1 2 3; U26 10 11 13 14; U28 1; U29 11; U35 14 15 16 17 19 21 23 24; U41 7; U43 1; U44 10 11 13 14; U45 3 8; U47 7 8 9 10; U50 1; U51 7; U52 2 5 6 11 12 13 14 15 18 19 20 21 22 23 24 25 27 29 30 31 32 41 44 45 46 53 54 56 57 65 67 83 84 85 86 91 92 102 103 104 105 106 107 108 109 110 111 112 116 117 118 119 120 121 123 124 125 126 127 128; U53 5; U55 2 4 5; U60 1 22 23 24; U66 5; U67 8 9; U68 1; U73 12 13 14; U80 7 19 21 23 25 27 29 31 32; U82 15 16 18 19 20 21; U84 6 7 31 32 33 34; U87 15 16 18 19 20 21; U89 15 16 18 19 20 21

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 2215 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
DGND: length 560.4
  TOP w0.203: J8.16 73.13,90.64 v1(73.27,90.79) 73.02,91.04 J8.18 ; J8.21 v1(74.29,91.84) ; J8.31 74.54,93.84 v1(74.29,94.09) 74.44,94.24 J8.33 ; J8.SH2 v1(73.73,87.31) J8.SH1 ; J8.17 74.54,91.04 v1(74.29,90.79) 74.44,90.64 J8.15 ; v1(104.79,11.71) 104.2,11.71 103.78,12.13 U2.3 ; 73.25,89.04 J8.8 ; J8.24 v1(71.53,92.24) ; U4.9 94.52,15.19 93.87,14.55 R18.2 ; J8.5 v1(74.29,88.64) 74.29,88.06 74.5,87.84 J8.1 ; J8.34 73.13,94.24 v1(73.27,94.09) 73.02,93.84 J8.32 ; J8.41 v1(74.29,95.84)
  TOP w0.254: U9.7 92.55,58.25 92.83,58.53 ; U15.5 106.27,88.67 U15.2 106.43,88.62 C97.2 ; v1(99.39,21.24) 98.8,21.24 98.44,20.87 98.44,19.81 98.83,19.41 C7.2 ; LD2.1 100.81,16.57 100.91,16.67 v1(101.47,16.67) ; v1(67.88,63.95) 66.99,63.95 66.69,63.65 65,63.65 64.65,63.3 R3844.1 ; R264.1 69.5,92.03 69.74,91.78 71.07,91.78 v1(71.53,92.24) ; v1(88.68,43.65) R464.2 87.97,44.23 88.23,44.49 U66.3 ; v1(84.58,75.3) 86.17,75.3 86.46,75.01 R242.2 ; v1(94.86,36.18) 95.05,36.37 R202.2 ; v1(91.59,55.51) U9.4
  TOP w0.305: v1(97.79,46.22) 98.19,45.81 U7.47 ; C96.2 v1(104.49,89.32) ; U29.2 22.53,22.41 23.35,21.6 C174.1 ; C97.2 v1(107.49,89.25) ; v1(97.02,36.07) 97.69,36.74 U7.1 ; v1(103.44,41.14) 104.19,40.39 U7.14 ; U7.48 97.69,45.55 ; C175.1 v1(25.52,23.99) ; U30.8 v1(33.27,59.14) ; v1(97.79,36.07) 98.19,36.47 U7.2 ; v1(104.01,48.63) v1(105.28,48.63)
  TOP w0.381: C168.2 v1(10.64,55.48) ; C206.2 90.62,70.04 v1(90.44,69.86) ; Q9.3 v1(55.11,91.85) ; C210.2 90.47,67.3 v1(90.44,67.32) ; C295.2 v1(29.74,14.34) ; U1.J12 v1(62.58,40.83) ; C360.2 v1(67.88,56.84) ; v1(54.68,63.63) 54.33,63.98 R461.2 C86.2 ; v1(52.7,26.36) 52.64,26.3 C330.1 ; U45.5 16.76,68.1 16.58,67.91 C237.2 16.05,68.12 16.05,68.49 v1(16.25,68.69) ; SW12.3 v1(62.11,106.25) ; v1(41.74,43.75) 41.79,43.7 C3744.2 ; v1(24.93,9.9) 24.93,9.89 C291.2 ; U1.J6 v1(56.98,40.83) ; v1(67.6,84.71) 67.59,84.71 R323.1 R324.1 R325.1 R326.1 ; v1(91.51,61.47) R56.1 C82.2 ; C176.2 16.76,26.26 v1(17.07,25.95) C348.1 ; C170.2 v1(23.49,53.33) ; U1.G12 v1(62.58,42.43) ; U18.4 v1(40.38,56.38) ; R188.2 v1(28.16,64.03) ; U1.V18 v1(67.38,32.83) 67.64,32.57 C108.2 ; U1.V1 53.37,33.22 v1(53.37,32.63) ; C314.2 v1(21.92,16.88) ; SW10.1 v1(46.4,96.84) ; C373.2 82.59,104.86 v1(83,105.27) ; U1.L12 v1(62.58,38.43) ; R3875.2 76.77,98.71 v1(76.46,98.39) ; C315.2 v1(32.84,16.88) ; U20.8 46.98,61.06 v1(47.38,60.65) ; C19.2 90.72,14.51 v1(90.55,14.34) ; C290.2 v1(20.08,10.76) ; U1.G10 v1(60.98,42.43) ; C236.2 v1(16.24,64.12) ; C361.2 v1(67.88,63.95) ; C323.2 v1(30.87,14.34) ; R89.2 v1(28.39,55.21) ; C157.2 v1(33.11,50.37) ; C305.2 v1(37.44,9.15) ; Q11.3 v1(63.69,93.59) ; Q21.2 36.79,31.1 37.3,30.59 v1(37.89,30.59) ; Q7.2 v1(111.63,59.29) ; C316.1 59.5,26.23 v1(59.56,26.28) ; U1.H9 v1(59.38,41.63) ; U1.L6 v1(56.98,38.43) ; v1(81.05,33.11) 80.8,33.37 U78.2 ; U1.M7 v1(57.78,37.63) ; R244.1 R243.1 R238.2 R237.2 C192.2 C191.2 ; U1.H7 v1(57.78,41.63) ; U73.8 v1(47.22,18.78) ; v1(72.26,39.69) 72.13,39.56 C149.2 ; U79.3 81.15,28.99 81.15,28.99 R434.2 v1(80.44,28.28) ; SW11.1 v1(55.15,95.53) ; J15.65 v1(46.24,4.56) ; R407.2 v1(55.78,8.9) ; C306.2 v1(23.9,14.34) ; U19.B3 v1(32.35,41.16) ; R396.2 59.3,29.6 v1(59.3,29.32) ; U69.2 v1(32.89,12.18) ; U19.E5 v1(29.35,45.16) ; v1(49.19,83.78) 49.19,82.49 48.29,81.59 R1383.1 ; R63.2 v1(45.97,35.68) ; v1(30.6,4.69) 31.04,4.25 J15.35 ; U1.E5 v1(56.18,44.03) ; U1.P12 v1(62.58,36.03) ; R410.2 v1(52.04,9.27) ; C280.2 C279.2 v1(30.22,28.2) ; C230.2 v1(15.74,47.5) ; U43.3 v1(42.29,29.37) ; C341.2 85.77,33.08 v1(86.07,33.38) 85.31,34.15 C340.2 ; U1.N11 v1(61.78,36.83) ; v1(106.53,57.03) 106.53,56.04 LD3.1 ; U1.K12 v1(62.58,39.23) ; R331.2 68.82,107.42 v1(68.81,107.41) C338.2 ; C233.2 18,42.86 U42.2 v1(15.81,42.08) ; J15.47 35.84,4.25 v1(35.17,4.91) ; R1649.1 v1(66.07,27.71) ; v1(73.27,89.01) 73.25,89.04 ; v1(109.11,48.64) 109.11,48.46 108.57,47.92 C79.2 ; v1(52.79,20.15) 52.79,20.15 52.88,20.06 R411.2 ; C307.2 v1(19.95,14.34) ; U1.T2 v1(53.78,34.43) ; U1.G7 v1(57.78,42.43) ; C76.2 106.8,33.74 v1(106.65,33.59) ; R18.2 C11.2 92.6,13.94 v1(92.83,13.7) ; C240.2 v1(50.4,74.17) ; U1.J11 v1(61.78,40.83) ; U61.2 v1(21.97,12.18) ; C331.2 R418.2 v1(42.67,25.9) ; U72.8 53.1,16.25 53.09,16.24 v1(53.09,16.19) ; U1.G9 v1(59.38,42.43) ; U36.3 v1(81.71,39.79) ; J15.157 103.24,4.13 103.66,4.56 v1(104.04,4.56) ; v1(103.12,33.39) 103.24,33.51 C66.2 102.29,34.2 C51.2 C54.2 ; R67.2 v1(45.99,67.66) ; U1.J9 v1(59.38,40.83) ; U1.H6 v1(56.98,41.63) ; U8.8 64.51,10.72 v1(64.51,10.72) ; v1(92.45,44.06) 92.45,44.06 R465.2 ; U1.J5 v1(56.18,40.83) ; U1.L13 v1(63.38,38.43) ; R220.1 v1(83.46,42.81) ; U1.K7 v1(57.78,39.23) ; v1(99.87,79.88) 99.87,80.45 100.25,80.83 C94.2 ; C211.2 v1(95.88,70.34) ; C337.2 v1(61.83,107.41) ; v1(101.13,88.77) 101.13,88.04 C95.2 ; U1.E12 v1(62.58,44.03) ; U1.N8 v1(58.58,36.83) ; v1(98.93,59.42) 99.4,58.95 LD20.1 ; U1.L8 v1(58.58,38.43) ; LD19.1 v1(72.72,30.35) ; C299.2 v1(29.7,10.8) ; v1(49.14,78.73) LD5.1 ; LD8.1 v1(88.38,41.25) ; C294.2 v1(25.01,15.1) ; SW12.1 v1(62.11,95.49) ; U1.M9 v1(59.38,37.63) ; LD21.1 72.07,78.05 v1(72.46,78.45) ; C244.2 v1(66.54,81.76) ; J15.135 v1(94.44,4.56) ; Y1.4 v1(46.02,30.72) ; U1.P13 v1(63.38,36.03) ; U1.F6 v1(56.98,43.23) ; U1.K11 v1(61.78,39.23) ; U1.N10 v1(60.98,36.83) ; U1.J13 v1(63.38,40.83) ; U1.M6 v1(56.98,37.63) ; C195.2 v1(95.88,68.84) ; U1.M11 v1(61.78,37.63) ; U1.R5 v1(56.18,35.23) ; U1.J10 v1(60.98,40.83) ; U1.L9 v1(59.38,38.43) ; C372.2 82.59,98.82 v1(83,98.41) ; C121.2 C120.2 70.38,44.66 v1(70.25,44.79) ; R49.2 v1(59.18,8.94) ; v1(87.9,67.32) 87.64,67.59 C191.2 ; v1(51.68,80) 51.99,80 52.45,79.54 Q2.2 ; U1.L14 v1(64.18,38.43) ; J15.179 112.04,4.81 v1(111.91,4.94) ; R50.2 v1(61.11,21.07) ; C212.2 86.68,66.93 86.46,67.14 C191.2 ; C174.1 v1(24.51,21.6) ; C148.2 72.13,41.37 v1(72.26,41.5) ; SW11.3 v1(55.15,106.25) ; U63.2 v1(27.81,12.18) ; U1.F8 v1(58.58,43.23) ; C336.2 v1(54.84,107.41) ; C197.2 v1(88.11,76.92) ; U41.4 v1(20.95,34.54) ; C169.2 v1(20.01,54.84) ; U1.P6 v1(56.98,36.03) ; C351.1 v1(45.42,106.63) ; C235.2 v1(20.02,63.57) ; U1.P10 v1(60.98,36.03) ; U1.J14 v1(64.18,40.83) ; U1.E13 v1(63.38,44.03) ; U1.H14 v1(64.18,41.63) ; C177.2 v1(40.25,64.67) ; U1.M8 v1(58.58,37.63) ; U1.A1 v1(52.98,47.23) ; C369.2 v1(83.84,85.42) ; U1.H13 v1(63.38,41.63) ; U1.M13 v1(63.38,37.63) ; C217.2 90.36,63.14 90.74,63.52 v1(91.15,63.52) ; U1.M12 v1(62.58,37.63) ; C30.2 100.16,48.36 v1(100.29,48.23) 100.18,48.12 C31.2 ; U1.E8 v1(58.58,44.03) ; LD22.1 v1(11.61,48.21) ; U1.J7 v1(57.78,40.83) ; Y1.2 47.72,32.91 v1(48.14,32.91) C185.2 C184.2 ; C322.2 v1(34.78,10.8) ; U1.R13 v1(63.38,35.23) ; R27.2 v1(79.74,24.82) ; R399.2 55.24,29.81 v1(55.72,29.32) ; v1(61.46,92.05) 61.39,91.98 Q10.3 ; U1.F13 v1(63.38,43.23) ; U1.L11 v1(61.78,38.43) ; U1.E14 v1(64.18,44.03) ; v1(22.6,4.56) 22.24,4.2 J15.13 ; v1(83,91.13) 82.45,91.13 82.14,91.44 C370.2 ; v1(58.84,5.46) 59.04,5.26 J15.97 ; C101.2 v1(52.14,35.98) ; v1(70.86,86.6) C221.2 C220.2 ; U1.E7 v1(57.78,44.03) ; v1(31.75,7.61) R416.2 ; v1(82.04,67.74) C219.2 ; Q4.2 49.68,55.36 49.51,55.19 R149.2 48.91,54.61 v1(48.63,54.33) ; U1.J8 v1(58.58,40.83) ; U1.F5 v1(56.18,43.23) ; C189.2 v1(80.63,43.79) ; U1.P5 v1(56.18,36.03) ; U1.L7 v1(57.78,38.43) ; C73.2 v1(59.82,21.07) ; U1.H8 v1(58.58,41.63) ; 12.31,52.34 v1(12.31,53.07) ; C362.2 v1(68.71,60.39) ; U57.9 v1(44.08,97.64) ; U1.F7 v1(57.78,43.23) ; v1(89.15,51.17) 88.76,51.56 R55.1 ; U22.3 v1(16.66,54.19) ; v1(73.78,97.65) 73.71,97.58 J8.SH4 ; U1.H10 v1(60.98,41.63) ; U1.M10 v1(60.98,37.63) ; U1.H12 v1(62.58,41.63) ; v1(56.8,58.15) R148.2 56.8,59.46 56.62,59.64 Q3.2 ; R189.2 v1(42.41,61.49) ; U1.H11 v1(61.78,41.63) ; C298.2 v1(25.92,9.13) ; J15.83 53.44,4.41 v1(53.72,4.69) ; C209.2 v1(95.88,67.34) ; v1(102.14,86.89) 102.11,86.86 102.11,86.63 102.02,86.55 R79.2 ; U1.E10 v1(60.98,44.03) ; C329.2 64.76,25.75 v1(64.76,26.36) ; 97.69,45.55 v1(97.02,46.22) ; U1.M14 v1(64.18,37.63) ; U1.F14 v1(64.18,43.23) ; U1.E6 v1(56.98,44.03) ; J15.111 v1(64.64,4.56) ; U1.G11 v1(61.78,42.43) ; U23.2 v1(15.21,56.25) ; R404.1 v1(60.7,30.6) ; U1.H5 v1(56.18,41.63) ; U1.K9 v1(59.38,39.23) ; C232.2 C231.2 v1(29.33,36.18) ; U1.N9 v1(59.38,36.83) ; U1.F12 v1(62.58,43.23) ; v1(81.97,66.07) C213.2 ; U46.4 v1(46.48,78.73) ; C321.2 v1(31,10.76) ; v1(105.67,33.62) C69.2 ; R110.2 v1(36.66,39.74) ; U1.P14 v1(64.18,36.03) ; U1.N7 v1(57.78,36.83) ; U1.G8 v1(58.58,42.43) ; U19.C1 v1(34.53,42.66) ; U1.L10 v1(60.98,38.43) ; SW10.3 v1(48.19,106.25) ; U1.N12 v1(62.58,36.83) ; U1.L5 v1(56.18,38.43) ; U1.A18 v1(67.38,47.23) ; U1.F10 v1(60.98,43.23) ; U1.K10 v1(60.98,39.23) ; C371.2 v1(84.68,89.99) ; J15.29 v1(28.64,4.56) ; 96.78,15.22 C16.2 ; C324.2 v1(34.82,14.34) ; U1.P8 v1(58.58,36.03) ; U1.K8 v1(58.58,39.23) ; U1.M5 v1(56.18,37.63)
  BOTTOM w0.203: J11.16 v1(52.74,100.99) ; U48.10 65.35,86.55 65.75,86.95 U48.11 ; J11.25 v1(57.24,103.59) ; J11.7 v1(48.24,100.97) ; J11.34 v1(61.74,103.39) ; v1(100.29,12.55) 100.29,12.78 100.64,13.13 U17.10 ; v1(98.93,59.42) C90.2 97.84,59.12 U12.7 ; J11.40 v1(64.74,103.34)
  BOTTOM w0.254: v1(102.14,86.89) 101.83,87.21 U14.1 ; 55.11,79.36 54.44,80.03 U10.1 ; U13.1 87.09,59.97 86.8,60.26 86.62,60.26 v1(86.32,60.56) ; U14.11 v1(101.13,88.77) ; U60.25 53.9,72.54 v1(53.53,72.9) ; U90.5 v1(76.4,37.24)
  BOTTOM w0.305: v1(64.18,44.03) 64.31,44.16 C105.2 ; v1(62.58,44.03) 62.45,43.9 C127.2 ; C107.2 56.07,38.54 v1(56.18,38.43) ; v1(64.18,41.63) 64.31,41.76 C155.2 ; v1(58.58,44.03) 58.69,43.92 C110.2 ; C128.2 56.31,43.1 v1(56.18,43.23) ; C152.2 57.97,44.22 v1(57.78,44.03) ; v1(62.58,36.03) 62.47,36.14 C136.2 ; C89.2 88.59,53.55 U13.7 ; C113.2 64.07,37.52 v1(64.18,37.63) ; v1(56.98,43.23) 57.11,43.1 C125.2 ; C109.2 53.91,34.56 v1(53.78,34.43) ; v1(63.38,37.63) 63.27,37.52 C116.2 ; v1(60.98,43.23) 61.09,43.12 C133.2 ; v1(58.58,43.23) 58.69,43.12 C126.2 ; U76.4 v1(52.06,92.44) ; C146.2 56.07,35.34 v1(56.18,35.23) ; v1(60.98,36.03) 60.98,36.01 C144.2 ; v1(64.18,38.43) 64.31,38.56 C153.2 ; C115.2 63.27,43.12 v1(63.38,43.23) ; v1(56.98,44.03) 56.85,44.16 C106.2 ; v1(59.38,42.43) 59.42,42.47 59.56,42.47 59.65,42.56 C111.2 ; U24.5 v1(28.44,52.18) ; C124.2 64.31,40.96 v1(64.18,40.83) 64.12,40.77 C112.2 ; v1(63.38,44.03) 63.19,44.22 C156.2 ; C118.2 60.85,44.16 v1(60.98,44.03) ; v1(77.13,27.42) 76.67,27.88 U81.5 ; v1(56.18,40.83) 56.18,40.4 C129.2 ; C123.2 62.71,40.7 v1(62.58,40.83) ; v1(56.98,36.03) 56.87,35.92 C143.2 ; C132.2 64.07,43.12 v1(64.18,43.23) ; C150.2 56.07,36.14 v1(56.18,36.03) ; C145.2 58.47,35.92 v1(58.58,36.03) ; C154.2 56.07,41.74 v1(56.18,41.63) ; v1(56.18,37.63) 56.07,37.52 C117.2 ; C131.2 56.85,38.56 v1(56.98,38.43) ; v1(57.78,36.83) 57.67,36.72 C137.2 ; v1(59.38,36.83) 59.27,36.72 C135.2 ; C114.2 62.71,39.36 v1(62.58,39.23) ; v1(56.98,40.83) 56.98,40.36 C122.2 ; v1(56.98,37.63) 56.87,37.52 C130.2
  BOTTOM w0.381: U56.5 v1(49.19,83.78) ; v1(35.91,23.99) 35.64,24.26 U67.13 ; v1(37.32,27.69) C188.2 R206.2 ; v1(95.26,81.26) C98.2 93.76,81.26 93.37,81.66 U16.2 ; v1(48.26,29.58) 48.26,29.78 C140.2 ; C187.1 22.25,29.23 J6.9 ; R166.2 v1(38.22,69.61) ; 53.37,32.6 53.75,32.98 C186.1 ; 53.37,32.6 R203.2 52.69,32.03 52.6,32.13 C141.2 ; 53.37,32.6 v1(53.37,32.63) 52.89,33.11 R187.2 52.5,32.89 C142.2 ; R281.2 R280.2 C234.2 v1(38.34,67.18) ; v1(112.9,10.78) 112.81,10.69 C332.2 ; R134.2 v1(52.62,48.79) ; C276.2 71.62,78.98 v1(71.99,79.35) ; v1(46.48,78.73) 46.43,78.78 45.71,78.78 R314.2 ; v1(65.27,86.47) 65.35,86.55 ; C284.2 v1(26.39,25.24) ; v1(64.28,82.81) C242.2 C243.2 v1(66.92,82.81) ; C134.2 v1(68.62,33.93) ; v1(10.48,46.28) 10.48,44.95 J4.14 10.37,43.71 v1(10.37,42.31) ; C181.1 v1(51.24,86.41) ; U70.3 v1(59.56,26.28) ; R170.1 110.18,95.87 v1(109.85,96.2) ; C333.2 v1(113.15,7.86) ; R165.2 v1(38.22,70.98) ; v1(71.88,67.95) R391.1 71.17,68.71 71.15,68.69 U59.8 ; R8.2 C1.2 98.45,14.2 v1(98.45,14.91) ; U39.3 v1(74.17,101.27) ; C247.2 v1(57.41,93.45) ; v1(81.05,33.11) 81.05,33.68 80.56,34.18 R3871.1 ; v1(23.9,14.34) 23.9,15.06 C292.2 ; C166.2 v1(37.56,35.32) ; U74.3 v1(64.76,26.36) ; U75.3 v1(52.7,26.36) ; v1(96.36,23.8) R16.2 R15.2 ; v1(70.25,44.79) C119.2 C103.2 v1(73.87,44.79) C102.2 ; J4.10 v1(23.21,45.93) ; C83.2 56.22,78.29 v1(56.31,78.2) ; U28.4 108.79,86.09 109.08,85.8 R169.1 v1(109.08,84.3) ; v1(16.25,73.9) 16.25,73.52 16.68,73.09 C275.2 ; C209.2 v1(95.88,67.34) ; C161.2 34.47,42.6 v1(34.53,42.66) ; C290.2 v1(20.08,10.76) ; C315.2 v1(32.84,16.88) ; C179.1 v1(34.78,72.9) ; R415.2 v1(51.78,28.15) ; U58.6 v1(19.78,73.36) ; v1(61.86,67.95) R389.1 R390.1 ; v1(91.6,101.84) 90.93,101.84 C365.2 ; U21.3 v1(32.99,37.22) ; v1(31.88,4.7) 31.84,4.66 J15.38 ; C299.2 v1(29.7,10.8) ; C222.2 v1(76.46,98.39) ; v1(82.04,67.74) 82.05,67.72 82.62,67.72 C214.2 ; v1(75.64,60.39) 75.39,60.64 C359.2 ; R215.2 v1(93.76,63.48) ; J4.11 v1(20.6,58.79) ; v1(85.72,63.55) 85.85,63.67 R245.2 ; U25.4 v1(29.53,56.12) ; v1(89.15,51.17) v1(89.15,52.18) 89.15,52.2 89.2,52.24 C89.2 ; C238.2 v1(47.62,98.58) ; v1(33.25,46.18) 33.25,45.89 32.51,45.16 R113.2 ; v1(35.17,4.91) 35.17,4.34 35.04,4.2 J15.46 ; v1(91.6,88.85) 90.93,88.85 C368.2 ; C139.2 64.18,36.02 v1(64.18,36.03) ; Q6.2 106.68,82.12 v1(106.99,81.81) ; R279.2 v1(25.94,69.37) ; v1(91.8,42.26) 91.8,41.22 C57.2 ; v1(59.3,29.32) R397.2 R82.2 R398.2 R400.2 v1(55.72,29.32) ; v1(68.96,98.54) 68.88,98.46 U49.3 ; v1(79.18,19.7) R24.2 80.66,19.33 C22.2 ; U31.5 v1(49.46,90.22) ; v1(57.38,76.78) 57.08,76.48 C277.2 ; v1(29.12,73.14) U32.4 ; C164.1 C162.2 31.97,40.63 32.35,41.01 v1(32.35,41.16) ; C335.2 v1(56.13,93.6) ; R17.2 91.61,23.04 91.01,22.44 C13.2 89.4,21.63 89.86,21.17 90.82,21.17 v1(91.44,20.56) ; C305.2 C304.2 38.49,10.13 38.1,10.53 U65.2 ; v1(87.27,81.59) 87.27,81.66 87.53,81.92 C100.2 C99.2 ; v1(88.11,76.92) C190.2 88.11,74.45 C196.2 ; v1(74.29,95.84) 74.59,96.14 R3874.2 ; v1(92.44,85.29) 92.67,85.06 C366.2 ; v1(29.74,14.34) 29.7,14.38 C300.2 ; C211.2 v1(95.88,70.34) ; v1(67.38,32.83) C104.2 67.38,30.78 68.33,29.83 R475.1 ; C364.2 92.49,105.44 v1(92.44,105.39) ; R330.1 v1(67.99,94.04) ; v1(43.06,59.97) 43.06,60.44 43.32,60.7 C172.1 ; v1(29.35,45.16) 29.43,45.24 C163.2 C160.2 ; J4.12 v1(15.25,57.33) ; J4.6 v1(23.49,53.33) ; v1(54.69,76.16) C278.2 R393.1 ; v1(46.45,40.88) 45.97,40.4 R3836.2 ; U69.2 v1(32.89,12.18) ; U27.5 v1(49.91,65.27) ; C357.2 v1(77.31,56.96) ; R266.1 v1(77.26,103) ; C24.2 v1(76.96,15.61) ; v1(95.88,68.84) C195.2 ; v1(61.37,93.03) 61.16,92.83 U50.3 ; R2.1 v1(104.52,16.62) ; R239.2 92.58,75.65 R240.2 93.42,75.9 v1(93.54,76.03) ; U63.2 v1(27.81,12.18) ; R168.1 v1(112.85,85.25) ; R405.2 v1(60.77,28.12) ; C241.2 v1(47.48,74.03) ; v1(28.55,16.83) 28.49,16.83 C282.2 ; v1(24.93,9.9) 24.93,9.89 C291.2 ; J15.32 29.44,4.15 29.45,4.15 29.45,6.86 v1(28.7,7.61) ; U59.16 v1(65.65,77.58) ; C171.2 v1(38.22,72.25) ; R205.2 v1(25.27,30.34) ; U61.2 v1(21.97,12.18) ; v1(77.31,63.82) C358.2 ; C246.1 v1(66.8,91.43) ; C334.2 v1(104.63,9.02) ; C356.2 v1(72.72,30.35) ; U5.5 R23.2 v1(87.1,18.34) ; U5.4 79.58,17.56 79.25,17.89 R26.1 78.59,18.3 C20.2 77.77,18.35 v1(77.77,19.22) ; C265.2 v1(50.9,97.02) ; v1(47.62,99.83) 47.62,99.83 C239.2 ; U26.8 v1(45.99,67.66) ; C93.2 v1(101.13,88.77) ; C307.2 v1(19.95,14.34) ; U54.4 v1(49.19,92.44) ; C281.2 v1(37.1,15.74) ; C298.2 v1(25.92,9.13) ; R164.2 v1(50.02,73.03) ; R241.2 v1(93,78.33) ; C216.2 v1(91.15,63.52) ; v1(92.44,92.4) 93.05,93.01 C367.2 ; R7.2 104.62,11.88 v1(104.79,11.71) ; Q8.2 v1(110.61,56.6) ; C173.2 v1(112.6,95.74) ; C319.2 34.78,14.38 v1(34.82,14.34) ; C3746.2 79.17,43.5 v1(78.91,43.76) 78.28,43.76 77.9,43.38 R3870.1 ; C193.2 v1(82.04,68.86) ; C363.2 v1(92.44,98.28) ; U58.5 v1(21.05,73.36) ; v1(27.55,71.73) U44.8 ; C272.1 v1(50.8,80) ; C245.1 v1(64.75,90.67) ; C321.2 v1(31,10.76) ; C323.2 v1(30.87,14.34) ; U33.8 v1(30.09,33.12)
  vias: v1(18.92,12.56) v1(23.24,73.65) v1(24.38,73.65) v1(25.65,73.65) v1(33.75,56.25) v1(33.75,54.47) v1(33.75,52.69) v1(35.15,56.25) v1(35.15,54.47) v1(35.15,52.69) v1(36.55,56.25) v1(36.55,54.47) v1(36.55,52.69) v1(39.89,48.31) v1(40.21,43.75) v1(40.21,42.6) v1(40.21,41.46) v1(40.21,40.32) v1(40.21,39.17) v1(40.21,38.03) v1(40.21,36.89) v1(40.98,43.75) v1(40.98,42.6) v1(40.98,41.46) v1(40.98,40.32) v1(40.98,39.17) v1(40.98,38.03) v1(40.98,36.89) v1(41.74,42.6) v1(41.74,41.46) v1(41.74,40.32) v1(41.74,39.17) v1(41.74,38.03) v1(41.74,36.89) v1(52.57,81.14) v1(53.46,81.14) v1(54.35,81.14) v1(55.19,71.01) v1(55.19,69.99) v1(55.19,68.97) v1(56.21,71.01) v1(56.21,69.99) v1(56.21,68.97) v1(57.22,71.01) v1(57.22,69.99) v1(57.22,68.97) v1(57.99,18.91) v1(58.67,82.03) v1(59.3,81.01) v1(61.21,81.27) v1(61.21,80.33) v1(62.23,81.27) v1(62.23,80.33) v1(67.88,62.68) v1(67.88,61.54) v1(67.88,60.39) v1(67.88,59.25) v1(67.88,58.11) v1(68.71,63.95) v1(68.71,62.68) v1(68.71,61.54) v1(68.71,59.25) v1(68.71,58.11) v1(68.71,56.84) v1(69.55,63.95) v1(69.55,62.68) v1(69.55,61.54) v1(69.55,59.25) v1(69.55,58.11) v1(69.55,56.84) v1(69.97,98.54) v1(70.99,98.54) v1(71.37,38.47) v1(74.34,24.19) v1(74.34,22.95) v1(74.34,22.31) v1(74.98,24.19) v1(74.98,22.95) v1(74.98,22.31) v1(75.64,63.82) v1(75.64,62.68) v1(75.64,61.54) v1(75.64,59.25) v1(75.64,58.11) v1(75.64,56.96) v1(76.47,63.82) v1(76.47,62.68) v1(76.47,61.54) v1(76.47,60.39) v1(76.47,59.25) v1(76.47,58.11) v1(76.47,56.96) v1(76.6,25.69) v1(77.24,25.69) v1(77.31,62.68) v1(77.31,61.54) v1(77.31,60.39) v1(77.31,59.25) v1(77.31,58.11) v1(77.87,25.69) v1(79.74,25.46) v1(83,104.12) v1(83,102.98) v1(83,101.84) v1(83,100.69) v1(83,99.55) v1(83,92.28) v1(83,89.99) v1(83,88.85) v1(83,87.7) v1(83,86.56) v1(83,85.42) v1(83.84,105.27) v1(83.84,104.12) v1(83.84,102.98) v1(83.84,101.84) v1(83.84,100.69) v1(83.84,99.55) v1(83.84,98.41) v1(83.84,92.28) v1(83.84,91.13) v1(83.84,89.99) v1(83.84,88.85) v1(83.84,87.7) v1(83.84,86.56) v1(84.68,105.27) v1(84.68,104.12) v1(84.68,102.98) v1(84.68,101.84) v1(84.68,100.69) v1(84.68,99.55) v1(84.68,98.41) v1(84.68,92.28) v1(84.68,91.13) v1(84.68,88.85) v1(84.68,87.7) v1(84.68,86.56) v1(84.68,85.42) v1(86.07,47.88) v1(86.13,30.81) v1(86.13,29.85) v1(87.08,33.07) v1(87.08,31.99) v1(87.08,30.81) v1(87.08,29.85) v1(87.28,48.55) v1(87.28,47.8) v1(87.9,69.86) v1(87.9,68.59) v1(88.41,48.56) v1(88.41,47.8) v1(89.17,69.86) v1(89.17,68.59) v1(89.17,67.32) v1(89.28,46.98) v1(89.28,46.09) v1(89.23,44.95) v1(89.56,48.55) v1(90.17,52.18) v1(90.44,68.59) v1(90.42,12.69) v1(90.66,54.53) v1(90.76,105.39) v1(90.76,104.12) v1(90.76,102.98) v1(90.76,100.82) v1(90.76,99.55) v1(90.76,98.28) v1(90.76,92.4) v1(90.76,91.13) v1(90.76,89.99) v1(90.76,87.7) v1(90.76,86.56) v1(90.76,85.29) v1(91.56,12.69) v1(91.6,105.39) v1(91.6,104.12) v1(91.6,102.98) v1(91.6,100.82) v1(91.6,99.55) v1(91.6,98.28) v1(91.6,92.4) v1(91.6,91.13) v1(91.6,89.99) v1(91.6,87.7) v1(91.6,86.56) v1(91.6,85.29) v1(91.59,54.55) v1(92.18,46.85) v1(92.44,104.12) v1(92.44,102.98) v1(92.44,101.84) v1(92.44,100.82) v1(92.44,99.55) v1(92.44,91.13) v1(92.44,89.99) v1(92.44,88.85) v1(92.44,87.7) v1(92.44,86.56) v1(92.88,36.03) v1(92.83,20.56) v1(94.19,60.08) v1(94.74,60.06) v1(96.09,36.17) v1(96.1,35.53) v1(97.03,46.92) v1(97.53,14.21) v1(97.57,12.72) v1(97.79,46.92) v1(99.07,88.97) v1(99.03,53.83) v1(99.03,51.8) v1(99.38,43.17) v1(99.38,42.16) v1(99.38,41.14) v1(99.38,40.12) v1(99.38,39.11) v1(99.8,53.83) v1(99.8,51.8) v1(100.4,43.17) v1(100.4,42.16) v1(100.4,41.14) v1(100.4,40.12) v1(100.4,39.11) v1(101.41,43.17) v1(101.41,42.16) v1(101.41,41.14) v1(101.41,40.12) v1(101.41,39.11) v1(101.47,18.91) v1(101.47,17.77) v1(102.23,24.37) v1(102.36,32.5) v1(102.36,30.34) v1(102.43,43.17) v1(102.43,42.16) v1(102.43,41.14) v1(102.43,40.12) v1(102.43,39.11) v1(102.48,22.97) v1(102.99,29.15) v1(102.99,28.23) v1(103.12,32.5) v1(103.12,30.34) v1(103.12,16.62) v1(103.44,43.17) v1(103.44,42.16) v1(103.44,40.12) v1(103.44,39.11) v1(104.14,29.15) v1(104.14,28.23) v1(104.44,53.83) v1(104.46,51.8) v1(104.46,43.17) v1(104.46,42.16) v1(104.46,41.14) v1(104.46,40.12) v1(104.46,39.11) v1(105.22,51.8) v1(105.28,29.15) v1(105.28,28.23) v1(105.48,43.17) v1(105.48,42.16) v1(105.48,41.14) v1(105.48,40.12) v1(105.48,39.11) v1(105.41,24.37) v1(105.41,22.97) v1(106.49,43.17) v1(106.49,42.16) v1(106.49,41.14) v1(106.49,40.12) v1(106.49,39.11) v1(106.68,29.15) v1(106.68,28.23) v1(107.51,43.17) v1(107.51,42.16) v1(107.51,41.14) v1(107.51,40.12) v1(107.51,39.11) v1(107.62,17.39) v1(107.69,22.47) v1(107.69,16.41) v1(108.52,43.17) v1(108.52,42.16) v1(108.52,41.14) v1(108.52,40.12) v1(108.52,39.11) v1(108.96,9.77) v1(109.22,16.43) v1(109.47,50.91)
