# Allegro board PROC159A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HSEC_ADC4_AIN1: length 9.6
  TOP w0.147: U1.V5 v1(56.18,32.83)
  L03_SIG1 w0.091: v1(53.59,26.36) 53.18,26.77 53.18,29.18 56.18,32.18 v1(56.18,32.83)
  BOTTOM w0.147: U75.4 53.2,25.96 v1(53.59,26.36)
HSEC_ADC-VREFHI: length 31.3
  TOP w0.147: R417.2 35.28,6.7 v1(35.17,6.59) ; v1(42.67,28.68) R418.1 C331.1 SW7.3
  L03_SIG1 w0.091: v1(42.67,28.68) 36.51,22.52 36.51,18.32 35.51,17.32 35.51,10.67 34.03,9.19 34.03,7.74 v1(35.17,6.59)
HSEC_DAC_OUT: length 29.9
  TOP w0.147: U1.T5 v1(56.18,34.43)
  L03_SIG1 w0.091: v1(50.54,25.39) 50.92,25.77 50.92,28.81 54.59,32.47 54.59,33.39 55.23,34.02 55.61,34.02 56.02,34.43 v1(56.18,34.43)
  BOTTOM w0.147: v1(50.54,25.39) 50.54,23.49 51.56,22.46 58.25,22.46 58.97,21.75 62.61,21.75 62.76,21.89 R412.2 R413.2
HSEC_EPWM0_A: length 56.6
  TOP w0.147: U1.B2 v1(53.78,46.43) ; J15.49 v1(36.64,4.56)
  L03_SIG1 w0.091: v1(53.78,46.43) 53.78,46.46 53.37,46.88 53.37,47.39 53.14,47.62 52.58,47.62 52.31,47.34 52.31,46.4 51.97,46.06 51.97,45.84 50.28,44.15 50.28,37.79 49.92,37.44 49.92,33.32 48.07,31.47 47.68,31.47 46.55,30.33 46.55,29.11 43.81,26.37 42.53,26.37 38.05,21.89 38.05,17.81 36.49,16.25 36.49,9.92 35.96,9.39 35.96,6.3 35.41,5.75 35.41,5.4 35.66,5.15 36.25,4.56 v1(36.64,4.56)
HSEC_EPWM0_B: length 52.9
  TOP w0.147: v1(36.64,6.59) 37.09,6.59 37.89,5.79 37.89,5.12 37.44,4.66 J15.51 ; U1.B1 v1(52.98,46.43)
  L03_SIG1 w0.091: v1(52.98,46.43) 52.94,46.43 52.34,45.83 52.34,45.63 50.64,43.93 50.64,37.64 50.29,37.29 50.29,33.17 48.21,31.09 47.83,31.09 46.91,30.18 46.91,28.96 38.42,20.46 38.42,17.66 37.52,16.77 37.52,11.03 37,10.51 37,8.42 37.41,8.01 37.41,7.36 v1(36.64,6.59)
HSEC_EPWM1_A: length 63.2
  TOP w0.147: J15.53 v1(38.24,4.56) ; U1.D3 v1(54.58,44.83)
  L03_SIG1 w0.091: v1(38.24,4.56) 37.81,4.13 35.35,4.13 34.75,4.73 34.75,5.56 35.78,6.59 35.78,9.47 36.3,10 36.3,16.32 37.87,17.89 37.87,21.97 42.45,26.55 43.73,26.55 46.37,29.18 46.37,30.4 47.61,31.65 47.99,31.65 49.74,33.39 49.74,37.55 50.09,37.9 50.09,44.22 51.77,45.9 51.77,46.12 52.09,46.44 52.09,47.55 52.35,47.82 53.74,47.82 54.17,47.39 54.17,46.29 54.44,46.02 54.74,46.02 54.97,45.79 54.97,45.22 v1(54.58,44.83)
HSEC_EPWM1_B: length 51.6
  TOP w0.147: J15.55 39.04,3.61 38.73,3.92 38.73,6.1 v1(38.24,6.59) ; U1.D2 v1(53.78,44.83)
  L03_SIG1 w0.091: v1(38.24,6.59) 38.24,6.96 38.4,7.13 38.4,10.73 38.97,11.3 38.97,20.23 47.46,28.73 47.46,29.93 48.01,30.48 48.38,30.48 51.51,33.61 51.51,35.34 50.89,35.96 50.89,36.85 51.61,37.57 51.61,40.14 51.86,40.39 51.86,44.26 52.82,45.22 53.39,45.22 v1(53.78,44.83)
HSEC_EPWM2_A: length 52.8
  TOP w0.147: U1.C2 v1(53.78,45.63)
  L03_SIG1 w0.091: v1(53.78,45.63) 53.55,45.63 53.16,46.02 52.82,46.02 52.57,45.77 52.57,45.59 51.5,44.52 51.5,40.54 51.24,40.29 51.24,37.72 50.47,36.94 50.47,33.09 48.29,30.91 47.9,30.91 47.1,30.1 47.1,28.88 38.6,20.39 38.6,11.45 37.61,10.45 37.61,10.33 37.88,10.06 37.88,7.19 36.64,5.95 v1(36.64,5.58)
  BOTTOM w0.147: J15.50 36.64,3.92 37.09,4.37 37.09,5.12 v1(36.64,5.58)
HSEC_EPWM2_B: length 51
  TOP w0.147: U1.C1 v1(52.98,45.63)
  L03_SIG1 w0.091: v1(37.44,5.58) 37.44,6.44 38.15,7.15 38.15,10.73 38.79,11.37 38.79,20.31 47.28,28.8 47.28,30 48,30.72 48.36,30.72 51.33,33.69 51.33,35.27 50.71,35.88 50.71,36.92 51.43,37.64 51.43,40.21 51.68,40.46 51.68,44.36 52.95,45.63 v1(52.98,45.63)
  BOTTOM w0.147: J15.52 v1(37.44,5.58)
HSEC_EPWM3_A: length 44.7
  TOP w0.147: U73.11 48.52,13.64 v1(49.64,14.75) ; U1.E2 v1(53.78,44.03)
  L03_SIG1 w0.091: v1(49.64,14.75) 53.49,18.61 55.15,18.61 55.72,19.17 55.72,20.44 55.3,20.86 55.3,29.64 58.17,32.51 58.17,39.6 57.91,39.86 55.24,39.86 54.99,40.11 54.99,41.81 55.16,41.98 55.18,41.98 55.22,42.02 55.64,42.02 55.79,42.17 55.79,44.27 55.65,44.42 55.22,44.42 54.97,44.17 54.97,43.87 54.74,43.64 54.17,43.64 v1(53.78,44.03)
HSEC_EPWM3_A/HSEC_MII1_CRS(RES0: length 33
  TOP w0.147: U73.9 v1(47.22,13.18)
  BOTTOM w0.147: J15.54 38.24,3.61 38.69,4.07 38.69,5.18 36.83,7.05 33.2,7.05 31.98,8.26 C318.1 ; C318.1 34.92,9.89 36.13,8.68 42.72,8.68 v1(47.22,13.18) ; C318.1 31.98,11.19 U68.3
HSEC_EPWM3_B: length 58.5
  TOP w0.147: U1.E3 v1(54.58,44.03)
  L03_SIG1 w0.091: v1(54.58,44.03) 54.19,44.42 54.19,45.77 53.92,46.04 53.62,46.04 53.37,46.29 53.37,46.59 53.14,46.82 52.71,46.82 52.55,46.65 52.55,46.38 52.15,45.99 52.15,45.75 50.46,44.06 50.46,37.72 50.11,37.37 50.11,33.24 48.14,31.28 47.75,31.28 46.73,30.25 46.73,29.03 38.24,20.54 38.24,17.74 36.67,16.17 36.67,9.85 36.14,9.32 36.14,7.86 v1(36.44,7.57)
  BOTTOM w0.147: v1(36.44,7.57) 38.52,7.57 39.04,7.04 J15.56
HSEC_EPWM4_A: length 51.4
  TOP w0.147: U1.D1 v1(52.98,44.83) ; v1(43.84,6.59) 43.04,5.79 J15.57
  L03_SIG1 w0.091: v1(52.98,44.83) 52.04,43.89 52.04,40.29 51.79,40.04 51.79,36.5 51.53,36.24 51.53,35.58 51.53,35.58 51.69,35.42 51.69,33.54 48.45,30.29 48.09,30.29 47.65,29.85 47.65,28.65 39.15,20.16 39.15,11.28 v1(43.84,6.59)
HSEC_EPWM4_B: length 55.7
  TOP w0.147: U1.E4 v1(55.38,44.03) ; J15.59 v1(43.84,4.56)
  L03_SIG1 w0.091: v1(55.38,44.03) 55.38,44 54.99,43.61 54.99,42.19 54.82,42.02 54.35,42.02 54.17,41.84 54.17,37.03 53.19,36.05 53.19,35.52 52.61,34.94 52.61,33.06 49.41,29.86 49.41,29.09 42.85,22.53 42.85,18.97 40.72,16.84 40.72,12.35 44.42,8.64 44.77,8.64 46.42,6.99 46.42,5.59 47.02,4.99 47.22,4.99 47.47,4.74 47.47,4.38 47.22,4.13 44.27,4.13 v1(43.84,4.56)
HSEC_EPWM5_A: length 51.6
  TOP w0.147: U1.F2 v1(53.78,43.23) ; v1(45.44,6.59) 44.64,5.79 J15.61
  L03_SIG1 w0.091: v1(45.44,6.59) 39.52,12.51 39.52,20.01 48.85,29.34 48.85,30.18 52.06,33.38 52.06,35.3 52.56,35.81 52.56,36.33 52.16,36.73 52.16,39.77 52.41,40.02 52.41,43.32 52.71,43.62 53.39,43.62 v1(53.78,43.23)
HSEC_EPWM5_B: length 49
  TOP w0.147: U1.G2 v1(53.78,42.43) ; J15.63 v1(45.44,4.56)
  L03_SIG1 w0.091: v1(45.44,4.56) 46.23,5.35 46.23,6.92 44.69,8.46 44.35,8.46 40.54,12.27 40.54,17.04 42.44,18.94 42.44,22.37 49.23,29.17 49.23,30.01 52.42,33.2 52.42,35.04 52.99,35.61 52.99,36.34 53.39,36.75 53.39,42.04 v1(53.78,42.43)
HSEC_EPWM6_A: length 50.6
  TOP w0.147: U1.E1 v1(52.98,44.03)
  L03_SIG1 w0.091: v1(52.98,44.03) 52.61,44.03 52.23,43.65 52.23,40.18 51.98,39.93 51.98,36.43 51.71,36.16 51.71,35.66 51.87,35.5 51.87,33.46 48.53,30.11 48.19,30.11 47.83,29.76 47.83,28.58 39.33,20.08 39.33,12.06 v1(43.84,7.56)
  BOTTOM w0.147: J15.58 43.04,6.76 v1(43.84,7.56)
HSEC_EPWM6_B: length 54.5
  TOP w0.147: U1.F3 v1(54.58,43.23)
  L03_SIG1 w0.091: v1(43.84,5.58) 44.27,5.15 45.62,5.15 46.05,5.58 46.05,6.84 44.61,8.28 44.27,8.28 39.7,12.85 39.7,19.9 49.05,29.24 49.05,30.08 52.24,33.27 52.24,35.16 52.77,35.69 52.77,36.45 52.34,36.87 52.34,39.63 52.59,39.89 52.59,42.59 52.82,42.82 54.17,42.82 v1(54.58,43.23)
  BOTTOM w0.147: v1(43.84,5.58) 43.38,5.12 43.38,4.37 43.84,3.92 J15.60
HSEC_EPWM7_A: length 62.7
  L03_SIG1 w0.091: v1(35.34,8.37) 35.34,9.69 36.12,10.48 36.12,16.4 37.69,17.96 37.69,22.04 42.38,26.73 43.66,26.73 45.58,28.66 45.58,30.88 47.18,32.48 48.31,32.48 49.56,33.73 49.56,37.62 49.91,37.97 49.91,44.63 50.29,45.02 50.29,46.25 50.94,46.9 v1(50.94,47.63)
  BOTTOM w0.147: R3880.2 50.66,47.63 v1(50.94,47.63) ; J15.62 44.64,4.16 44.41,4.39 44.41,7.65 43.99,8.06 35.64,8.06 v1(35.34,8.37)
HSEC_EPWM7_B: length 69
  TOP w0.147: v1(44.61,45.04) 44.89,45.31 44.89,45.44 45.21,45.76 45.58,45.76 R3876.2
  L03_SIG1 w0.091: v1(44.61,45.04) 44.92,45.34 44.92,45.44 45.16,45.69 46.06,45.69 47.36,46.99 48.59,46.99 49.73,45.85 49.73,38.05 49.38,37.7 49.38,34.78 48.08,33.48 47.4,33.48 44.41,30.49 44.41,29.32 37.51,22.42 37.51,19.06 35.82,17.37 35.82,10.72 34.57,9.48 v1(34.57,8.35)
  BOTTOM w0.147: J15.64 45.44,3.92 44.81,4.54 44.81,7.87 44.31,8.38 35.98,8.38 35.51,8.84 35.07,8.84 v1(34.57,8.35)
HSEC_EPWM11_A: length 68.5
  TOP w0.147: R190.2 49.04,44.95 48.13,44.95 v1(47.62,45.45)
  L03_SIG1 w0.091: v1(47.62,45.45) 48.12,44.95 48.97,44.95 49.55,44.38 49.55,38.13 49.19,37.77 49.19,34.86 48,33.67 47.33,33.67 44.16,30.51 44.16,29.34 37.08,22.25 v1(37.08,20.43)
  BOTTOM w0.147: v1(37.08,20.43) 48.55,20.43 51.54,17.45 53.42,17.45 54.36,16.51 54.36,15.84 55.68,14.52 55.68,12.42 56.35,11.75 56.35,8.73 54.24,6.62 J15.86
HSEC_EPWM13_A: length 108.7
  TOP w0.147: J15.153 101.64,4.07 102.44,4.87 v1(102.44,5.58)
  L08_SIG2 w0.091: v1(48.51,44.35) 49.4,45.24 49.4,46.48 48.34,47.54 44.79,47.54 44.23,48.09 44.23,50.72 45.03,51.51 55.76,51.51 57.37,53.13 59.79,53.13 60.11,53.45 60.11,53.93 60.24,54.06 64.87,54.06 66.03,52.89 67.03,52.89 67.79,52.13 69.55,52.13 70.48,51.2 70.48,50.67 70.8,50.35 73.62,50.35 75.06,48.91 75.06,47.82 77.39,45.49 77.39,40.19 79,38.58 79,31.4 82.67,27.73 82.67,19.83 87.73,14.77 90.94,14.77 97.03,8.69 97.03,7.51 97.42,7.11 98.01,7.11 99.06,6.07 101.18,6.07 101.67,5.58 v1(102.44,5.58)
  BOTTOM w0.147: R192.2 v1(48.51,44.35)
HSEC_EPWM13_B: length 112
  L08_SIG2 w0.091: v1(48.51,43.21) 48.08,43.64 48.08,44.53 48.33,44.78 48.66,44.78 49.12,45.24 49.12,46.32 48.12,47.33 44.63,47.33 43.97,47.98 43.97,50.78 44.88,51.69 55.56,51.69 57.18,53.31 58.46,53.31 59.4,54.25 64.95,54.25 66.11,53.09 67.11,53.09 67.87,52.33 69.7,52.33 70.75,51.27 70.75,50.79 70.94,50.6 73.78,50.6 75.17,49.22 76.83,49.22 77.66,48.38 77.66,40.31 79.24,38.73 79.24,31.5 82.91,27.83 82.91,20.02 87.87,15.06 92.18,15.06 98.36,8.88 98.36,7.71 98.97,7.1 101.07,7.1 101.58,6.59 v1(102.44,6.59)
  BOTTOM w0.147: J15.154 101.64,4.06 101.91,4.34 101.91,6.07 v1(102.44,6.59) ; R196.2 v1(48.51,43.21)
HSEC_EPWM21_A: length 45.1
  TOP w0.147: v1(55.09,6.61) 55.84,5.87 J15.89 ; R209.2 74.21,35.95 v1(74.47,35.69)
  L03_SIG1 w0.091: v1(74.47,35.69) 75.94,34.22 75.94,33.18 73.72,30.96 73.72,29.74 70.98,26.99 70.98,24.13 69.32,22.46 69.32,18.59 65.34,14.61 63.52,14.61 55.52,6.61 v1(55.09,6.61)
HSEC_EPWM21_B: length 47.1
  TOP w0.147: R207.2 74.21,38.51 74.47,38.26 v1(74.47,37.75)
  L03_SIG1 w0.091: v1(74.47,37.75) 76.29,35.93 76.29,32.67 74.08,30.47 74.08,29.64 71.22,26.78 71.22,23.99 69.61,22.38 69.61,18.4 65.49,14.28 63.74,14.28 56.6,7.14 v1(56.6,6.61)
  BOTTOM w0.147: v1(56.6,6.61) 55.84,5.85 J15.90
HSEC_EQEP0_A: length 58.5
  TOP w0.147: U1.B14 v1(64.18,46.43)
  L08_SIG2 w0.091: v1(61.43,7.35) 61.17,7.62 60.83,7.62 60.04,8.41 60.04,10.67 65.18,15.82 66.92,15.82 69.8,18.7 69.8,22.49 70.9,23.59 70.9,28.45 71.12,28.66 71.12,30.44 70.45,31.1 70.45,33.18 72.03,34.76 72.03,38.75 71.39,39.4 71.39,40.97 66.94,45.43 66.94,46.91 66.23,47.62 65.62,47.62 65.37,47.37 65.37,47.07 65.14,46.84 64.59,46.84 v1(64.18,46.43)
  BOTTOM w0.147: J15.102 60.64,6.56 v1(61.43,7.35)
HSEC_EQEP0_B: length 67.6
  TOP w0.147: U1.A14 v1(64.18,47.23)
  L08_SIG2 w0.091: v1(59.81,6.46) 60.11,6.16 61.62,6.16 61.87,6.41 61.87,7.52 61.49,7.9 60.81,7.9 60.22,8.49 60.22,10.47 61.01,11.26 61.51,11.26 62.85,9.93 64.33,9.93 64.94,10.54 64.94,13.3 69.51,17.87 71.67,17.87 72.49,18.69 72.49,22.96 73.44,23.91 73.44,25.8 72.22,27.03 72.22,34.17 72.7,34.66 72.7,40.41 71.06,42.06 71.06,43.02 70.45,43.63 69.71,43.63 68.36,44.99 68.36,47.19 67.48,48.06 65.01,48.06 v1(64.18,47.23)
  BOTTOM w0.147: v1(59.81,6.46) 60.29,5.98 60.29,4.37 59.84,3.91 J15.100
HSEC_EQEP0_INDEX: length 76.8
  TOP w0.147: U1.D11 v1(61.78,44.83)
  L08_SIG2 w0.091: v1(63.03,7.57) 63.99,7.57 66.56,10.15 66.56,12.49 67.34,13.27 67.34,14.12 69.97,16.75 75.13,16.75 76.16,17.77 76.16,33.84 75.17,34.83 75.17,38.15 74.49,38.83 74.49,43.34 74.14,43.69 73.38,43.69 70.89,46.17 70.89,47.42 70.51,47.8 69.87,47.8 68.19,49.48 67.46,49.48 66.74,50.2 65.44,50.2 63.86,51.78 63.86,52.47 63.48,52.84 62.76,52.84 62.17,52.26 62.17,45.22 v1(61.78,44.83)
  BOTTOM w0.147: J15.106 62.24,6.78 v1(63.03,7.57)
HSEC_EQEP0_STROBE: length 69.5
  TOP w0.147: U1.C12 v1(62.58,45.63)
  L08_SIG2 w0.091: v1(61.44,5.5) 61.81,5.5 62.23,5.92 62.23,7.68 61.64,8.27 60.96,8.27 60.6,8.62 60.6,9.13 60.96,9.49 64.41,9.49 65.31,10.39 65.31,13.15 69.66,17.5 71.99,17.5 72.98,18.49 72.98,22.76 73.91,23.68 73.91,26.03 72.96,26.97 72.96,29.11 73.43,29.58 73.43,30.87 72.88,31.42 72.88,34.06 73.43,34.62 73.43,41.68 70.99,44.12 69.92,44.12 68.85,45.19 68.85,47.41 67.65,48.61 67.09,48.61 66.39,49.3 64.82,49.3 63.37,47.85 63.37,46.97 62.99,46.59 62.99,46.04 v1(62.58,45.63)
  BOTTOM w0.147: v1(61.44,5.5) 60.98,5.04 60.98,4.37 61.44,3.92 J15.104
HSEC_EQEP2_A: length 137
  L08_SIG2 w0.091: v1(46.04,68.78) 29.01,68.78 28,67.77 26.15,67.77 19.09,60.71 19.09,58.13 14.76,53.8 14.76,38.96 17.03,36.69 17.03,35.23 14.05,32.25 13.49,32.25 12.81,31.58 12.81,27.68 13.71,26.78 13.71,23.18 18.48,18.41 24.04,18.41 24.23,18.59 v1(24.82,18.59)
  BOTTOM w0.147: v1(46.04,68.78) 46.22,68.96 U26.6 ; v1(24.82,18.59) 26.14,19.92 35.77,19.92 37.09,21.24 49.31,21.24 52.58,17.98 55.17,17.98 57.14,16 57.14,4.42 56.83,4.1 56.82,4.1 56.64,3.93 J15.92
HSEC_EQEP2_B: length 148.8
  TOP w0.147: v1(58.24,6.59) 57.44,5.79 J15.93
  L08_SIG2 w0.091: v1(46.03,70.73) 45.6,70.29 31.32,70.29 30.54,71.08 26.2,71.08 13.9,58.78 13.9,38.53 15.54,36.88 15.54,34.52 13.83,32.8 11.24,32.8 10.09,31.65 10.09,24.97 11.08,23.98 11.79,23.98 12.96,22.81 12.96,22.01 17.46,17.51 v1(23.87,17.51)
  BOTTOM w0.147: v1(46.03,70.73) 46.05,70.73 46.23,70.91 U26.3 ; v1(23.87,17.51) 23.87,18.29 24.63,19.05 24.65,19.05 25.81,20.21 35.64,20.21 36.97,21.54 49.43,21.54 52.7,18.27 56.05,18.27 59.77,14.55 59.77,8.68 58.24,7.15 v1(58.24,6.59)
HSEC_EQEP2_INDEX: length 71.6
  TOP w0.147: U1.A12 v1(62.58,47.23)
  L08_SIG2 w0.091: v1(61.21,8.88) 65.03,8.88 66.38,10.22 66.38,10.7 65.82,11.26 65.82,13.15 69.81,17.14 74.83,17.14 75.67,17.97 75.67,27.72 74.56,28.83 74.56,31.16 74.89,31.49 74.89,33.66 74.39,34.15 74.25,34.15 73.92,34.48 73.92,41.83 69.33,46.42 69.33,47.61 67.89,49.05 67.3,49.05 66.57,49.79 64.32,49.79 62.58,48.05 v1(62.58,47.23)
  BOTTOM w0.147: J15.94 57.44,5.15 58.69,6.4 58.69,7.19 60.38,8.88 v1(61.21,8.88)
HSEC_EQEP2_STROBE: length 77.3
  TOP w0.147: U1.B12 v1(62.58,46.43) ; J15.95 v1(58.24,4.56)
  L08_SIG2 w0.091: v1(58.24,4.56) 58.67,4.99 60.02,4.99 60.27,4.74 60.27,4.61 61.11,3.77 62.85,3.77 63.47,4.38 63.47,6.67 63.17,6.96 62.78,6.96 62.42,7.32 62.42,7.74 61.71,8.45 61.03,8.45 60.78,8.7 60.78,9.05 61.03,9.3 64.48,9.3 65.49,10.31 65.49,13.07 69.74,17.32 74.67,17.32 75.42,18.07 75.42,27.62 73.91,29.14 73.91,33.88 73.68,34.11 73.68,41.75 71.09,44.34 70.01,44.34 69.07,45.28 69.07,47.53 67.78,48.83 67.19,48.83 66.47,49.54 64.61,49.54 63.08,48.01 63.08,47.16 62.58,46.66 v1(62.58,46.43)
HSEC_EXT_REFCLK0: length 45.5
  TOP w0.147: U1.P2 v1(53.78,36.03)
  L03_SIG1 w0.091: v1(53.78,36.03) 53.39,35.64 53.39,35.43 52.83,34.86 52.83,32.99 49.6,29.76 49.6,29.02 47.94,27.36 47.94,22.72 41.38,16.16 41.38,12.72 44.43,9.67 46.2,9.67 47.26,8.62 49.23,8.62 v1(50.24,7.61)
  BOTTOM w0.147: v1(50.24,7.61) 49.44,6.81 J15.74
HSEC_GPIO: length 94.2
  TOP w0.147: v1(52.75,67.83) 52.25,68.33 45.59,68.33 44.37,67.11 44.37,61.86 43.83,61.31 43.83,60.4 46.44,57.78 v1(46.44,56.66)
  BOTTOM w0.147: v1(46.44,56.66) 46.44,55.92 42.39,51.87 42.39,46.85 44.15,45.1 44.15,44.7 45.42,43.43 45.86,43.43 46.38,42.9 46.38,41.74 46.91,41.21 46.91,40.65 45.35,39.09 45.35,36.74 43.95,35.35 43.95,31.83 49.1,26.69 49.1,24.3 51.47,21.92 57.47,21.92 58.58,20.81 58.58,17.73 61.72,14.6 61.72,8.74 60.02,7.05 59.75,7.05 58.99,6.28 58.99,6.28 57.78,5.08 57.78,4.37 58.24,3.92 J15.96 ; v1(52.75,67.83) 52.75,68.09 52.9,68.24 U60.17
HSEC_I2C1_SCL: length 97.8
  TOP w0.147: J15.87 v1(55.04,4.56) ; U1.D7 v1(57.78,44.83) ; R152.2 v1(57.84,49.14)
  L08_SIG2 w0.091: v1(55.04,4.56) 56.2,3.4 63,3.4 63.83,4.23 63.83,6.64 66.79,9.6 67.11,9.92 67.11,12.21 69.29,14.39 74.72,14.39 81.14,20.81 81.14,28.6 78.45,31.28 78.45,38.35 76.84,39.97 76.84,43.97 74.47,46.33 74.47,48.69 73.33,49.82 70.06,49.82 69.26,50.62 69.26,51.24 68.75,51.75 67.62,51.75 66.86,52.51 65.87,52.51 64.79,53.58 61.72,53.58 60.45,52.32 60.11,52.32 59.53,51.74 59.53,51.4 57.84,49.71 v1(57.84,49.14) 59.17,47.8 59.17,46.77 58.97,46.57 58.97,45.47 58.74,45.24 58.19,45.24 v1(57.78,44.83)
HSEC_I2C1_SDA: length 103
  TOP w0.147: R153.2 v1(56.7,49.14) ; U1.C8 v1(58.58,45.63) ; v1(55.03,5.62) 54.71,5.3 54.71,5.29 54.24,4.82 J15.85
  L08_SIG2 w0.091: v1(55.03,5.62) 54.61,5.21 54.61,4.38 55.78,3.22 63.08,3.22 64.01,4.16 64.01,6.45 67.3,9.74 67.3,12.14 69.37,14.21 74.88,14.21 81.38,20.71 81.38,28.67 78.76,31.3 78.76,38.44 77.11,40.08 77.11,45.38 74.83,47.66 74.83,48.74 73.46,50.1 70.18,50.1 69.51,50.76 69.51,51.4 68.97,51.94 67.7,51.94 66.94,52.7 65.95,52.7 64.87,53.79 61.5,53.79 60.36,52.64 59.98,52.64 59.52,52.18 58.56,52.18 56.7,50.32 v1(56.7,49.14) 57.18,48.65 57.8,48.65 58.97,47.48 58.97,47.07 58.74,46.84 58.44,46.84 58.19,46.59 58.19,46.02 v1(58.58,45.63)
HSEC_MCAN5_RX: length 48.3
  L03_SIG1 w0.091: v1(51.84,5.58) 50.65,5.58 49.81,6.41 49.81,7.04 48.6,8.25 47.03,8.25 45.97,9.31 44.28,9.31 40.9,12.68 40.9,16.37 46.9,22.37 46.9,24.02 v1(47.38,24.5)
  BOTTOM w0.147: v1(51.84,5.58) 51.38,5.12 51.38,4.37 51.84,3.92 J15.80 ; v1(47.38,24.5) 45.86,26.01 43.96,26.01 38.15,31.82 U33.11
HSEC_MCAN5_TX: length 50.3
  L03_SIG1 w0.091: v1(47.33,23.63) 47.33,22.46 41.16,16.29 41.16,12.68 44.35,9.49 46.05,9.49 47.11,8.43 48.81,8.43 50.06,7.18 53.01,7.18 v1(53.44,7.61)
  BOTTOM w0.147: v1(53.44,7.61) 52.64,6.81 J15.82 ; U33.14 35.34,29.87 36.62,31.15 38.33,31.15 43.8,25.67 45.28,25.67 v1(47.33,23.63)
HSEC_MII0_COL: length 122.7
  TOP w0.147: v1(72.9,66.32) 73.3,65.92 73.3,64.07 73.98,63.39 U87.24
  L03_SIG1 w0.091: v1(72.9,66.32) 73.19,66.02 75.49,66.02 76.96,67.49 76.96,67.78 77.37,68.19 78.64,68.19 84.17,62.66 84.17,56.59 86.42,54.34 86.42,49.64 86.81,49.25 86.81,47.35 86.5,47.04 86.5,44.42 83.8,41.72 83.8,32.88 84.78,31.9 84.78,22.98 89.31,18.45 89.31,17.23 90.24,16.3 90.65,16.3 90.96,15.99 90.96,15.38 91.61,14.73 91.61,13.7 92.27,13.05 92.27,12.33 91.65,11.71 91.65,8.88 92.13,8.39 92.62,8.39 93.1,8.86 v1(93.51,8.86)
  BOTTOM w0.147: v1(93.51,8.86) 93.89,9.25 93.89,10.64 93.07,11.46 90.43,11.46 89.62,12.27 89.62,12.74 88.76,13.6 69.83,13.6 69.23,12.99 69.23,11.79 64.64,7.2 64.64,6.59 63.62,5.57 63.62,4.26 63.84,4.04 J15.110
HSEC_MII0_CRS: length 87.8
  TOP w0.147: v1(92.46,8.87) 90,8.87 88.84,7.71 J15.121 ; U87.22 74.17,65 v1(74.17,66.7)
  L03_SIG1 w0.091: v1(74.17,66.7) 74.68,67.21 75.82,67.21 76.55,67.94 76.55,68.29 77.37,69.11 78.76,69.11 79.08,68.79 79.08,68.13 83.52,63.69 84.44,62.78 84.44,56.71 86.69,54.46 86.69,49.8 87.85,48.64 87.85,47.05 86.78,45.98 86.78,44.31 84.07,41.6 84.07,33 85.05,32.02 85.05,23.22 89.69,18.58 89.69,17.76 90.19,17.26 90.65,17.26 90.95,16.96 90.95,16.48 91.24,16.19 91.24,15.5 91.93,14.81 91.93,13.78 92.54,13.16 92.54,12.2 91.89,11.55 91.89,9.06 92.08,8.87 v1(92.46,8.87)
HSEC_MII0_RXCLK: length 98.1
  TOP w0.147: J15.123 89.64,3.85 90.15,4.36 90.15,7.16 v1(89.57,7.73) ; U87.28 v1(73.94,61.39)
  L03_SIG1 w0.091: v1(89.57,7.73) 89.27,8.04 89.27,13.46 86.66,16.06 84.68,16.06 84.55,16.2 84.55,16.6 84.42,16.74 84.23,16.74 84.09,16.6 84.09,16.2 83.96,16.06 83.77,16.06 83.63,16.2 83.63,16.6 83.5,16.74 83.31,16.74 83.18,16.6 83.18,16.2 83.04,16.06 82.85,16.06 82.72,16.2 82.72,16.6 82.59,16.74 82.4,16.74 82.26,16.6 82.26,16.2 82.13,16.06 81.94,16.06 81.81,16.2 81.81,16.6 81.67,16.74 81.48,16.74 81.35,16.6 81.35,16.2 81.22,16.06 81.03,16.06 80.89,16.2 80.89,16.6 80.76,16.74 80.57,16.74 80.43,16.6 80.43,16.2 80.3,16.06 80.11,16.06 79.98,16.2 79.98,16.6 79.84,16.74 79.65,16.74 79.52,16.6 79.52,16.2 79.39,16.06 78.64,16.06 78.25,16.45 78.25,17.52 80.29,19.55 80.29,20.55 80.42,20.68 80.78,20.68 80.91,20.81 80.91,21 80.78,21.14 80.42,21.14 80.29,21.27 80.29,21.46 80.42,21.59 80.78,21.59 80.91,21.73 80.91,21.92 80.78,22.05 80.42,22.05 80.29,22.19 80.29,22.37 80.42,22.51 80.78,22.51 80.91,22.64 80.91,22.83 80.78,22.97 80.42,22.97 80.29,23.1 80.29,23.29 80.42,23.42 80.78,23.42 80.91,23.56 80.91,23.75 80.78,23.88 80.42,23.88 80.29,24.01 80.29,24.2 80.42,24.34 80.78,24.34 80.91,24.47 80.91,24.66 80.78,24.79 80.42,24.79 80.29,24.93 80.29,25.12 80.42,25.25 80.78,25.25 80.91,25.39 80.91,25.57 80.78,25.71 80.42,25.71 80.29,25.84 80.29,26.03 80.42,26.17 80.78,26.17 80.91,26.3 80.91,26.49 80.78,26.62 80.42,26.62 80.29,26.76 80.29,27.35 79.82,27.82 79.82,28.61 79.46,28.97 79.46,40.85 81.09,42.48 81.09,44.13 80.68,44.55 80.68,50.17 81.76,51.26 81.76,61.16 82,61.39 82,62.43 79.32,65.11 78.69,65.11 77.86,64.28 75.2,64.28 73.48,62.56 73.48,61.85 v1(73.94,61.39)
HSEC_MII0_RXD0: length 98.3
  TOP w0.147: v1(72.18,55.11) 72.93,54.36 76.63,54.36 77.22,54.95 U87.42 ; v1(91.24,7.61) 90.73,7.1 90.73,4.4 90.44,4.1 J15.125
  L03_SIG1 w0.091: v1(91.24,7.61) 91.24,11.69 91.99,12.44 91.99,12.9 91.34,13.55 91.34,14.58 90.68,15.23 90.41,15.23 88.74,16.89 88.74,18.46 84.5,22.7 84.5,31.75 83.52,32.73 83.52,41.84 85.09,43.4 85.09,48.92 84.65,49.36 84.65,53.58 83.89,54.34 83.89,62.48 79.17,67.2 77.15,67.2 75.65,65.69 72.69,65.69 70.55,63.55 70.55,58.42 71.01,57.97 71.4,57.97 71.72,57.64 71.72,56.64 72.18,56.17 v1(72.18,55.11)
HSEC_MII0_RXD1: length 98.2
  TOP w0.147: U87.40 76.22,55.26 76.07,55.11 74.99,55.11 74.79,55.32 v1(74.33,55.32)
  L03_SIG1 w0.091: v1(74.33,55.32) 74.61,55.59 74.61,59 74.2,59.41 73.74,59.41 73.5,59.65 73.5,61.45 73.21,61.73 73.21,62.75 75.02,64.56 77.75,64.56 78.57,65.38 79.44,65.38 82.33,62.48 82.33,61.3 82.04,61 82.04,51.15 80.95,50.06 80.95,44.66 81.37,44.25 81.37,42.3 79.73,40.67 79.73,29.87 81.42,28.19 81.42,24.54 81.55,24.41 81.95,24.41 82.08,24.27 82.08,24.08 81.95,23.95 81.55,23.95 81.42,23.81 81.42,23.63 81.55,23.49 81.95,23.49 82.08,23.36 82.08,23.17 81.95,23.03 81.55,23.03 81.42,22.9 81.42,22.71 81.55,22.58 81.95,22.58 82.08,22.44 82.08,22.25 81.95,22.12 81.55,22.12 81.42,21.99 81.42,21.8 81.55,21.66 81.95,21.66 82.08,21.53 82.08,21.34 81.95,21.21 81.55,21.21 81.42,21.07 81.42,20.88 81.55,20.75 81.95,20.75 82.08,20.61 82.08,20.43 81.95,20.29 81.55,20.29 81.42,20.16 81.42,19.97 81.55,19.83 81.95,19.83 82.08,19.7 82.08,19.51 81.95,19.38 81.55,19.38 81.42,19.24 81.42,19.05 81.55,18.92 81.95,18.92 82.08,18.79 82.08,18.6 81.95,18.46 81.55,18.46 81.42,18.33 81.42,17.79 81.97,17.24 85.87,17.24 89.54,13.57 89.54,9.65 90.01,9.19 90.01,5.94 v1(89.64,5.58)
  BOTTOM w0.147: v1(89.64,5.58) 90.44,4.78 J15.126
HSEC_MII0_RXD2: length 98.6
  TOP w0.147: v1(91.24,5.58) 91.71,5.1 91.71,4.37 91.24,3.9 J15.127 ; U87.37 v1(73.94,56.89)
  L03_SIG1 w0.091: v1(91.24,5.58) 90.8,6.01 90.8,12 91.14,12.33 91.14,13.28 91.03,13.38 91.03,14.49 90.58,14.94 89.5,14.94 85.93,18.51 83.88,18.51 83.33,19.06 83.33,28.01 82.53,28.82 82.53,29.23 82.66,29.37 82.98,29.37 83.11,29.5 83.11,29.69 82.98,29.83 82.66,29.83 82.53,29.96 82.53,30.15 82.66,30.28 82.98,30.28 83.11,30.42 83.11,30.61 82.98,30.74 82.66,30.74 82.53,30.87 82.53,31.06 82.66,31.2 82.98,31.2 83.11,31.33 83.11,31.52 82.98,31.65 82.66,31.65 82.53,31.79 82.53,31.98 82.66,32.11 82.98,32.11 83.11,32.25 83.11,32.44 82.98,32.57 82.66,32.57 82.53,32.7 82.53,32.89 82.66,33.03 82.98,33.03 83.11,33.16 83.11,33.35 82.98,33.48 82.66,33.48 82.53,33.62 82.53,33.81 82.66,33.94 82.98,33.94 83.11,34.07 83.11,34.26 82.98,34.4 82.66,34.4 82.53,34.53 82.53,34.72 82.66,34.86 82.98,34.86 83.11,34.99 83.11,35.18 82.98,35.31 82.66,35.31 82.53,35.45 82.53,35.64 82.66,35.77 82.98,35.77 83.11,35.9 83.11,36.09 82.98,36.23 82.66,36.23 82.53,36.36 82.53,45.84 83.76,47.07 83.76,49.34 82.86,50.24 82.86,60.66 83.32,61.13 83.32,62.66 79.78,66.2 78.23,66.2 77.45,65.42 72.81,65.42 70.83,63.44 70.83,59.06 70.99,58.89 71.37,58.89 71.86,58.4 72.43,58.4 v1(73.94,56.89)
HSEC_MII0_RXD3: length 98.4
  TOP w0.147: U87.35 v1(73.94,57.89)
  L03_SIG1 w0.091: v1(73.94,57.89) 73.41,57.89 72.86,58.44 72.86,58.87 72.34,59.39 71.99,59.39 71.68,59.7 71.68,63.11 71.96,63.39 72.98,63.39 74.73,65.15 77.56,65.15 78.34,65.93 79.66,65.93 82.97,62.62 82.97,61.16 82.59,60.78 82.59,49.88 82.86,49.6 82.86,46.57 82.17,45.88 82.17,41.1 82.04,40.97 81.29,40.97 81.16,40.83 81.16,40.65 81.29,40.51 82.04,40.51 82.17,40.38 82.17,39.55 81.54,38.91 81.54,38.59 81.67,38.46 81.99,38.46 82.13,38.32 82.13,38.13 81.99,38 81.67,38 81.54,37.87 81.54,37.68 81.67,37.54 81.99,37.54 82.13,37.41 82.13,37.22 81.99,37.09 81.67,37.09 81.54,36.95 81.54,36.76 81.67,36.63 81.99,36.63 82.13,36.49 82.13,36.3 81.99,36.17 81.67,36.17 81.54,36.04 81.54,35.85 81.67,35.71 81.99,35.71 82.13,35.58 82.13,35.39 81.99,35.26 81.67,35.26 81.54,35.12 81.54,34.93 81.67,34.8 81.99,34.8 82.13,34.67 82.13,34.48 81.99,34.34 81.67,34.34 81.54,34.21 81.54,34.02 81.67,33.88 81.99,33.88 82.13,33.75 82.13,33.56 81.99,33.43 81.67,33.43 81.54,33.29 81.54,33.1 81.67,32.97 81.99,32.97 82.13,32.84 82.13,32.65 81.99,32.51 81.67,32.51 81.54,32.38 81.54,32.19 81.67,32.06 81.99,32.06 82.13,31.92 82.13,31.73 81.99,31.6 81.67,31.6 81.54,31.46 81.54,31.28 81.67,31.14 81.99,31.14 82.13,31.01 82.13,30.82 81.99,30.68 81.67,30.68 81.54,30.55 81.54,30.36 81.67,30.23 81.99,30.23 82.13,30.09 82.13,29.9 81.99,29.77 81.67,29.77 81.54,29.64 81.54,29.25 82.98,27.81 82.98,18.63 83.46,18.15 85.81,18.15 90.86,13.1 90.86,12.44 90.55,12.13 90.55,5.25 v1(91.24,4.56)
  BOTTOM w0.147: J15.128 v1(91.24,4.56)
HSEC_MII0_RXDV: length 98.3
  TOP w0.147: U87.33 v1(73.94,58.89)
  L03_SIG1 w0.091: v1(89.64,4.56) 90.26,5.19 90.26,9.36 89.81,9.81 89.81,13.71 85.84,17.69 83.14,17.69 82.59,18.24 82.59,24.71 82.45,24.85 81.91,24.85 81.78,24.98 81.78,25.17 81.91,25.3 82.45,25.3 82.59,25.44 82.59,25.63 82.45,25.76 81.91,25.76 81.78,25.89 81.78,26.08 81.91,26.22 82.45,26.22 82.59,26.35 82.59,27.76 80.76,29.59 80.76,32.25 80.01,33 80.01,34.27 80.14,34.41 81.05,34.41 81.19,34.54 81.19,34.73 81.05,34.86 80.14,34.86 80.01,35 80.01,35.19 80.14,35.32 81.05,35.32 81.19,35.46 81.19,35.64 81.05,35.78 80.14,35.78 80.01,35.91 80.01,36.87 80.14,37.01 81.07,37.01 81.21,37.14 81.21,37.33 81.07,37.46 80.14,37.46 80.01,37.6 80.01,37.79 80.14,37.92 81.07,37.92 81.21,38.05 81.21,38.24 81.07,38.38 80.14,38.38 80.01,38.51 80.01,38.7 80.14,38.83 81.07,38.83 81.21,38.97 81.21,39.16 81.07,39.29 80.14,39.29 80.01,39.43 80.01,40.36 81.64,41.99 81.64,46.54 81.98,46.88 81.98,50.67 82.31,51 82.31,60.89 82.64,61.22 82.64,62.57 79.55,65.66 78.46,65.66 77.67,64.87 74.84,64.87 72.87,62.9 72.87,60.38 72.59,60.1 72.59,59.66 73.36,58.89 v1(73.94,58.89)
  BOTTOM w0.147: J15.124 v1(89.64,4.56)
HSEC_MII0_RXER: length 98.2
  TOP w0.147: U87.31 v1(73.94,59.89)
  L03_SIG1 w0.091: v1(83.12,15.24) 78.04,15.24 77.41,15.87 77.41,17.92 78.73,19.25 78.73,22.23 78.6,22.36 77.8,22.36 77.67,22.5 77.67,22.69 77.8,22.82 78.6,22.82 78.73,22.96 78.73,23.15 78.6,23.28 77.8,23.28 77.67,23.41 77.67,23.6 77.8,23.74 78.6,23.74 78.73,23.87 78.73,24.31 78.46,24.58 78.46,30.41 78.32,30.54 78.32,42.52 80.13,44.33 80.13,50.4 81.22,51.49 81.22,61.38 81.35,61.51 81.35,62.31 79.72,63.93 78.5,63.93 77.69,63.12 75.45,63.12 74.61,62.28 74.61,61.18 73.94,60.5 v1(73.94,59.89)
  BOTTOM w0.147: v1(83.12,15.24) 81.77,13.89 69.71,13.89 69.54,13.72 68.93,13.11 68.93,11.91 64.09,7.06 64.09,6.63 62.58,5.12 62.58,4.37 63.04,3.92 J15.108
HSEC_MII0_RXLINK: length 98.1
  TOP w0.147: U87.26 v1(73.94,62.39)
  L03_SIG1 w0.091: v1(73.94,62.39) 74.27,62.39 75.28,63.4 77.58,63.4 77.98,63.8 77.98,64.02 78.8,64.83 79.21,64.83 81.62,62.42 81.62,61.4 81.49,61.27 81.49,51.37 80.4,50.29 80.4,44.21 78.6,42.41 78.6,41.72 78.71,41.62 79.21,41.62 79.31,41.51 79.31,41.36 79.21,41.25 78.71,41.25 78.6,41.14 78.6,40.99 78.71,40.88 79.08,40.88 79.19,40.78 79.19,40.63 79.08,40.52 78.71,40.52 78.6,40.41 78.6,40.26 78.71,40.15 79.08,40.15 79.19,40.05 79.19,39.89 79.08,39.79 78.71,39.79 78.6,39.68 78.6,39.53 78.71,39.42 79.08,39.42 79.19,39.31 79.19,39.16 79.08,39.06 78.71,39.06 78.6,38.95 78.6,38.8 78.71,38.69 79.08,38.69 79.19,38.58 79.19,38.43 79.08,38.32 78.71,38.32 78.6,38.22 78.6,38.07 78.71,37.96 79.08,37.96 79.19,37.85 79.19,37.7 79.08,37.59 78.71,37.59 78.6,37.49 78.6,37.33 78.71,37.23 79.08,37.23 79.19,37.12 79.19,36.97 79.08,36.86 78.71,36.86 78.6,36.75 78.6,36.6 78.71,36.5 79.08,36.5 79.19,36.39 79.19,36.24 79.08,36.13 78.71,36.13 78.6,36.02 78.6,35.87 78.71,35.76 79.08,35.76 79.19,35.66 79.19,35.51 79.08,35.4 78.71,35.4 78.6,35.29 78.6,35.14 78.71,35.03 79.08,35.03 79.19,34.93 79.19,34.77 79.08,34.67 78.71,34.67 78.6,34.56 78.6,34.41 78.71,34.3 79.08,34.3 79.19,34.19 79.19,34.04 79.08,33.94 78.71,33.94 78.6,33.83 78.6,33.68 78.71,33.57 79.08,33.57 79.19,33.46 79.19,33.31 79.08,33.2 78.71,33.2 78.6,33.1 78.6,32.95 78.71,32.84 79.08,32.84 79.19,32.73 79.19,32.58 79.08,32.47 78.71,32.47 78.6,32.37 78.6,32.21 78.71,32.11 79.08,32.11 79.19,32 79.19,31.85 79.08,31.74 78.71,31.74 78.6,31.63 78.6,31.48 78.71,31.37 79.08,31.37 79.19,31.27 79.19,31.12 79.08,31.01 78.71,31.01 78.6,30.9 78.6,30.75 78.71,30.64 79.08,30.64 79.19,30.54 79.19,30.38 79.08,30.28 78.85,30.28 78.76,30.19 78.76,24.95 79.96,23.75 79.96,19.75 77.85,17.64 77.85,16.07 78.22,15.69 86.65,15.69 88.99,13.35 88.99,6.99 v1(89.4,6.58)
  BOTTOM w0.147: J15.122 88.84,6.02 v1(89.4,6.58)
HSEC_MII0_TXCLK: length 120.7
  TOP w0.147: v1(92.84,6.59) 92.04,5.79 J15.129
  L03_SIG1 w0.091: v1(84.09,96.55) 84.09,97.04 84.32,97.27 85.17,97.27 85.46,96.97 85.46,96.74 85.36,96.63 84.83,96.63 84.72,96.52 84.72,96.37 84.83,96.26 85.36,96.26 85.46,96.16 85.46,95.95 85.28,95.76 83.13,95.76 82.62,95.25 82.62,93.9 81.91,93.2 81.91,92.41 81.8,92.3 81.05,92.3 80.95,92.19 80.95,92.04 81.05,91.93 81.8,91.93 81.91,91.83 81.91,91.68 81.8,91.57 81.05,91.57 80.95,91.46 80.95,91.31 81.05,91.2 81.8,91.2 81.91,91.1 81.91,90.94 81.8,90.84 81.05,90.84 80.95,90.73 80.95,90.58 81.05,90.47 81.8,90.47 81.91,90.36 81.91,85.06 82.07,84.9 82.53,84.44 84.23,84.44 85.58,83.09 85.96,83.09 86.51,82.53 86.51,81.02 86.75,80.78 86.75,74.95 87.62,74.09 87.62,70.71 87.18,70.28 87.18,66.45 86.75,66.02 86.75,63.55 86,62.8 85.46,62.8 85.26,62.6 85.26,59.03 85.67,58.62 85.67,58.47 85.53,58.33 85.53,58.18 85.63,58.07 85.78,58.07 85.92,58.21 86.08,58.21 86.18,58.11 86.18,57.95 86.04,57.81 86.04,57.66 86.15,57.56 86.3,57.56 86.44,57.7 86.59,57.7 86.7,57.59 86.7,57.44 86.56,57.3 86.56,57.15 86.67,57.04 86.82,57.04 86.96,57.18 87.11,57.18 87.22,57.07 87.22,56.92 87.08,56.78 87.08,56.63 87.18,56.52 87.34,56.52 87.48,56.66 87.63,56.66 87.89,56.4 87.89,50.92 90.03,48.78 90.03,46.13 89.56,45.66 88.8,45.66 87.6,44.46 87.6,23.25 91.61,19.25 91.61,18.63 92.43,17.81 92.43,15.51 93.81,14.13 93.81,11.37 94.21,10.96 94.21,8.36 92.84,6.98 v1(92.84,6.59)
  BOTTOM w0.147: U88.40 v1(84.09,96.55)
HSEC_MII0_TXD0: length 120.4
  TOP w0.147: J15.131 v1(92.84,4.56)
  L03_SIG1 w0.091: v1(92.84,4.56) 94.23,5.95 94.23,7.21 95.04,8.02 95.04,11.3 94.64,11.7 94.64,14.74 93.26,16.11 93.26,19.18 92.31,20.14 92.31,20.83 88.42,24.71 88.42,39.72 89.95,41.24 89.95,44.69 90.85,45.6 90.85,50.32 89.67,51.5 89.67,52.8 89.22,53.25 89.22,57.46 88.93,57.75 88.93,57.9 89.21,58.18 89.21,58.34 89.1,58.44 88.95,58.44 88.67,58.16 88.52,58.16 88.41,58.27 88.41,58.42 88.69,58.7 88.69,58.85 88.59,58.96 88.44,58.96 88.15,58.68 88,58.68 87.9,58.78 87.9,58.94 88.18,59.22 88.18,59.37 88.07,59.48 87.92,59.48 87.64,59.19 87.49,59.19 87.38,59.3 87.38,59.45 87.66,59.74 87.66,59.89 87.55,59.99 87.4,59.99 87.12,59.71 86.97,59.71 86.76,59.92 86.76,61.85 87.59,62.68 87.59,65.54 88.72,66.66 88.72,70.54 89.09,70.91 89.09,76.55 88.03,77.61 88.03,81.86 87.36,82.53 87.36,82.85 86.25,83.96 85.94,83.96 85.13,84.77 85.13,92.29 86.38,93.54 87.18,93.54 87.75,92.98 87.75,89.92 87.93,89.74 88.3,89.74 88.51,89.95 88.51,95.24 86.38,97.37 v1(86.38,98.34)
  BOTTOM w0.147: U88.37 v1(86.38,98.34)
HSEC_MII0_TXD1: length 120.7
  L03_SIG1 w0.091: v1(92.84,5.58) 93.21,5.58 93.96,6.32 93.96,7.32 94.76,8.13 94.76,11.19 94.37,11.59 94.37,14.62 92.99,16 92.99,19.07 92.03,20.02 92.03,20.69 88.15,24.57 88.15,39.83 89.67,41.35 89.67,44.81 90.58,45.71 90.58,49.01 88.46,51.13 88.46,56.74 88.24,56.96 88.24,57.11 88.51,57.38 88.51,57.53 88.4,57.64 88.25,57.64 87.98,57.37 87.83,57.37 87.72,57.47 87.72,57.62 87.99,57.9 87.99,58.05 87.89,58.16 87.73,58.16 87.46,57.88 87.31,57.88 87.2,57.99 87.2,58.14 87.48,58.41 87.48,58.57 87.37,58.67 87.22,58.67 86.94,58.4 86.79,58.4 86.69,58.51 86.69,58.66 86.96,58.93 86.96,59.08 86.85,59.19 86.7,59.19 86.43,58.92 86.28,58.92 85.81,59.38 85.81,61.28 87.3,62.77 87.3,65.71 88.44,66.85 88.44,71.15 88.82,71.52 88.82,75.5 87.33,76.98 87.33,80.21 87.76,80.64 87.76,81.75 87.08,82.42 87.08,82.74 86.15,83.67 85.78,83.67 84.46,84.98 82.76,84.98 82.46,85.28 82.46,92.87 83.66,94.08 84.52,94.08 84.62,94.18 84.62,94.53 84.73,94.64 84.88,94.64 84.99,94.53 84.99,94.18 85.1,94.08 85.25,94.08 85.35,94.18 85.35,94.53 85.46,94.64 85.61,94.64 85.72,94.53 85.72,94.18 85.83,94.08 86.97,94.08 87.39,94.5 87.39,95.92 85.86,97.44 85.86,98.82 v1(86.38,99.34)
  BOTTOM w0.147: U88.35 v1(86.38,99.34) ; v1(92.84,5.58) 93.32,5.09 93.32,4.36 92.84,3.87 J15.132
HSEC_MII0_TXD2: length 120.5
  TOP w0.147: v1(91.24,6.59) 91.84,7.2 91.84,7.7 92.33,8.19 92.94,8.19 93.64,7.49 J15.133
  L03_SIG1 w0.091: v1(91.24,6.59) 91.76,6.06 92.97,6.06 93.42,6.51 93.42,7.17 94.49,8.24 94.49,11.07 94.08,11.48 94.08,14.33 92.71,15.71 92.71,18.94 91.7,19.95 91.29,19.95 87.87,23.36 87.87,44.35 88.91,45.39 89.67,45.39 90.3,46.02 90.3,48.9 88.18,51.02 88.18,56.61 85.54,59.24 85.54,61.4 87.03,62.89 87.03,65.91 87.46,66.34 87.46,70.17 87.89,70.6 87.89,76.03 87.06,76.87 87.06,80.89 86.79,81.16 86.79,82.64 86.07,83.36 85.69,83.36 84.34,84.71 82.65,84.71 82.19,85.17 82.19,93.08 83.61,94.5 83.61,95.29 83.79,95.46 85.46,95.46 85.94,95.95 85.94,96.96 85.49,97.41 85.49,99.45 v1(86.38,100.34)
  BOTTOM w0.147: U88.33 v1(86.38,100.34)
HSEC_MII0_TXD3: length 120.7
  L03_SIG1 w0.091: v1(86.38,101.34) 85.87,101.85 85.44,101.85 85.18,101.59 85.18,97.89 84.88,97.59 82.65,97.59 81.63,96.57 81.19,96.57 80.62,96 80.62,94.27 79.61,93.26 79.61,84.76 81.14,83.23 84.48,83.23 85.17,82.54 85.73,82.54 85.97,82.3 85.97,80.8 86.21,80.56 86.21,74.72 87.07,73.86 87.07,70.94 86.64,70.51 86.64,66.73 86.21,66.29 86.21,64.47 85.83,64.09 85.23,64.09 84.72,63.57 84.72,57.25 86.97,55 86.97,51.07 88.85,49.18 88.85,47.57 87.05,45.77 87.05,44.09 84.35,41.39 84.35,33.11 85.33,32.13 85.33,23.69 90.94,18.07 90.94,17.51 91.17,17.28 91.58,17.28 91.88,16.97 91.88,15.28 93.26,13.91 93.26,10.59 v1(92.46,9.78)
  BOTTOM w0.147: U88.31 v1(86.38,101.34) ; v1(92.46,9.78) 92.78,9.46 92.78,9.4 92.98,9.2 92.98,8.72 93.96,7.75 93.96,4.38 93.64,4.06 J15.134
HSEC_MII0_TXEN: length 120.7
  L03_SIG1 w0.091: v1(92.84,7.61) 93.1,7.87 93.34,7.87 93.94,8.47 93.94,10.85 93.53,11.25 93.53,14.02 92.16,15.39 92.16,17.69 91.33,18.52 91.33,19.05 85.6,24.78 85.6,42.21 87.33,43.94 87.33,45.66 89.13,47.46 89.13,49.29 87.24,51.18 87.24,55.11 86.97,55.39 86.97,55.54 87.05,55.62 87.05,55.78 86.95,55.88 86.79,55.88 86.71,55.8 86.56,55.8 86.45,55.9 86.45,56.05 86.54,56.14 86.54,56.29 86.43,56.4 86.28,56.4 86.19,56.31 86.04,56.31 85.93,56.42 85.93,56.57 86.02,56.66 86.02,56.81 85.91,56.92 85.76,56.92 85.67,56.83 85.52,56.83 84.99,57.36 84.99,62.71 85.35,63.07 85.89,63.07 86.48,63.66 86.48,66.14 86.91,66.57 86.91,70.4 87.34,70.83 87.34,73.97 86.48,74.84 86.48,80.67 86.24,80.91 86.24,82.42 85.84,82.81 85.46,82.81 84.18,84.1 80.66,84.1 79.88,84.88 79.88,85.39 79.99,85.5 80.38,85.5 80.49,85.6 80.49,85.76 80.38,85.86 79.99,85.86 79.88,85.97 79.88,86.12 79.99,86.23 80.38,86.23 80.49,86.34 80.49,86.49 80.38,86.59 79.99,86.59 79.88,86.7 79.88,86.85 79.99,86.96 80.38,86.96 80.49,87.07 80.49,87.22 80.38,87.33 79.99,87.33 79.88,87.43 79.88,88.49 79.99,88.59 80.38,88.59 80.49,88.7 80.49,88.85 80.38,88.96 79.99,88.96 79.88,89.07 79.88,89.22 79.99,89.32 80.38,89.32 80.49,89.43 80.49,89.58 80.38,89.69 79.99,89.69 79.88,89.8 79.88,89.95 79.99,90.06 80.38,90.06 80.49,90.16 80.49,90.31 80.38,90.42 79.99,90.42 79.88,90.53 79.88,90.68 79.99,90.79 80.38,90.79 80.49,90.89 80.49,91.05 80.38,91.15 79.99,91.15 79.88,91.26 79.88,91.41 79.99,91.52 80.38,91.52 80.49,91.63 80.49,91.78 80.38,91.88 79.99,91.88 79.88,91.99 79.88,92.14 79.99,92.25 80.38,92.25 80.49,92.36 80.49,92.51 80.38,92.62 79.99,92.62 79.88,92.72 79.88,92.9 81.55,94.57 81.55,95.55 82.56,96.55 v1(83.09,96.55)
  BOTTOM w0.147: v1(92.84,7.61) 92.04,6.81 J15.130 ; U88.42 v1(83.09,96.55)
HSEC_MII1_COL: length 102
  L03_SIG1 w0.091: v1(86.38,91.85) 85.68,91.15 85.68,85.02 86.09,84.61 87.92,84.61 88.19,84.33 89.21,84.33 89.61,83.93 89.61,81.47 89.13,80.99 89.13,78.06 91.25,75.94 91.25,71.57 91.87,70.95 91.87,66.04 92.69,65.22 92.69,61.25 91.14,59.71 91.14,54.16 92.26,53.05 92.26,47.87 92.65,47.47 92.65,45.84 91.04,44.24 91.04,40.78 89.52,39.26 89.52,26.37 95.12,20.77 95.66,20.77 96.1,20.32 96.1,19.19 95.87,18.95 95.87,12.6 96.52,11.95 96.52,7.08 v1(96.04,6.59)
  BOTTOM w0.147: v1(96.04,6.59) 95.24,5.79 J15.138 ; U89.24 v1(86.38,91.85)
HSEC_MII1_CRS(RES0_PWMOUT0): length 178.9
  TOP w0.147: v1(47.22,14.32) 47.87,13.67 U73.10 ; J15.139 96.04,3.91 95.5,4.45 95.5,7.07 v1(96.04,7.61)
  L03_SIG1 w0.091: v1(86.38,92.85) 85.4,91.87 85.4,84.9 85.97,84.33 87.3,84.33 88.39,83.23 89.02,83.23 89.34,82.92 89.34,81.59 88.85,81.1 88.85,77.95 90.98,75.82 90.98,71.46 91.6,70.84 91.6,65.92 92.41,65.11 92.41,61.36 90.19,59.14 90.19,53.69 91.67,52.2 91.67,45.26 90.77,44.35 90.77,40.9 89.25,39.38 89.25,26.25 95.01,20.48 95.01,18.82 95.59,18.25 95.59,12.49 96.04,12.04 v1(96.04,7.61)
  L08_SIG2 w0.091: v1(47.22,14.32) 46.8,13.9 46.8,11.1 44.63,8.93 44.63,4.21 45.9,2.93 63.62,2.93 65.41,4.72 65.41,7.38 66.49,8.47 67.54,8.47 68.69,9.62 68.69,12.16 70.16,13.63 91.65,13.63 96.04,9.25 v1(96.04,7.61)
  BOTTOM w0.147: U89.22 v1(86.38,92.85)
HSEC_MII1_RXCLK: length 106.4
  TOP w0.147: v1(99.32,6.59) 97.75,8.17 97.31,8.17 96.84,7.69 J15.141
  L03_SIG1 w0.091: v1(99.32,6.59) 99.82,7.08 99.82,8.87 98.72,9.97 98.72,14.02 97.96,14.77 97.96,15.48 99.16,16.68 99.16,20.33 96.91,22.58 96.91,26.57 92.16,31.32 92.16,39.3 94.9,42.05 94.9,49.76 95.76,50.62 95.76,59.71 95.04,60.43 95.04,65.26 94.23,66.07 94.23,70.99 93.82,71.4 93.82,73.6 93.11,74.31 93.11,77.29 93.74,77.92 93.74,82.72 94.6,83.57 94.6,84.54 93.83,85.31 93.83,86.94 92.53,88.23 91.07,88.23 90,89.3 86.92,89.3 v1(86.38,89.85)
  BOTTOM w0.147: U89.28 v1(86.38,89.85)
HSEC_MII1_RXD0: length 106.3
  TOP w0.147: J15.143 v1(97.64,4.56)
  L03_SIG1 w0.091: v1(97.64,4.56) 98.45,4.56 98.97,4.05 98.97,3.18 98.74,2.95 98.33,2.95 98.19,3.08 98.19,3.61 98.06,3.74 97.87,3.74 97.73,3.61 97.73,3.08 97.6,2.95 93.77,2.95 93.41,3.31 93.41,4.68 94.91,6.18 94.91,7.51 95.31,7.9 95.31,11.99 95.04,12.26 95.04,14.87 93.65,16.26 93.65,20.42 88.7,25.38 88.7,39.6 90.22,41.13 90.22,44.58 91.13,45.48 91.13,51.98 89.64,53.46 89.64,59.36 91.05,60.77 91.05,61.77 90.7,62.12 89.16,62.12 88.93,62.34 88.93,66.25 89.62,66.93 89.62,71.76 90.39,72.53 90.39,75.64 88.3,77.72 88.3,82.21 v1(87.8,82.71)
  BOTTOM w0.147: v1(87.8,82.71) 83.7,82.71 83.09,83.32 U89.42
HSEC_MII1_RXD1: length 106.2
  L03_SIG1 w0.091: v1(87.09,83.73) 87.46,83.73 88.27,82.92 88.27,82.67 88.58,82.36 88.58,77.83 90.7,75.71 90.7,72.37 89.95,71.62 89.95,66.65 89.3,66 89.3,62.95 89.7,62.54 91.58,62.54 91.95,62.16 91.95,61.29 89.91,59.25 89.91,53.58 91.4,52.09 91.4,45.37 90.49,44.47 90.49,41.01 88.97,39.49 88.97,25.52 93.95,20.54 93.95,16.35 95.31,14.98 95.31,12.38 95.59,12.11 95.59,7.79 95.28,7.49 95.28,6.08 93.75,4.55 93.75,3.56 94.02,3.29 94.51,3.29 94.65,3.42 94.65,3.89 94.78,4.02 94.97,4.02 95.1,3.89 95.1,3.42 95.24,3.29 95.43,3.29 95.56,3.42 95.56,3.89 95.7,4.02 95.88,4.02 96.02,3.89 96.02,3.42 96.15,3.29 96.7,3.29 97.15,3.73 97.15,5.08 v1(97.64,5.58)
  BOTTOM w0.147: U89.40 84.09,83.71 84.4,83.41 86.77,83.41 v1(87.09,83.73) ; v1(97.64,5.58) 97.1,5.04 97.1,4.45 97.64,3.92 J15.144
HSEC_MII1_RXD2: length 106.2
  TOP w0.147: v1(97.64,7.61) 98.18,7.06 98.18,4.25 98.44,4 J15.145
  L03_SIG1 w0.091: v1(97.64,7.61) 97.07,8.17 97.07,12.17 96.43,12.81 96.43,18.66 96.72,18.95 96.72,20.83 90.07,27.47 90.07,28.41 90.21,28.55 90.74,28.55 90.88,28.68 90.88,28.87 90.74,29 90.21,29 90.07,29.14 90.07,29.33 90.21,29.46 90.74,29.46 90.88,29.59 90.88,29.78 90.74,29.92 90.21,29.92 90.07,30.05 90.07,30.24 90.21,30.37 90.74,30.37 90.88,30.51 90.88,30.7 90.74,30.83 90.21,30.83 90.07,30.97 90.07,31.15 90.21,31.29 90.74,31.29 90.88,31.42 90.88,31.61 90.74,31.75 90.21,31.75 90.07,31.88 90.07,32.07 90.21,32.2 90.74,32.2 90.88,32.34 90.88,32.53 90.74,32.66 90.21,32.66 90.07,32.79 90.07,32.98 90.21,33.12 90.74,33.12 90.88,33.25 90.88,33.44 90.74,33.57 90.21,33.57 90.07,33.71 90.07,33.9 90.21,34.03 90.74,34.03 90.88,34.17 90.88,34.36 90.74,34.49 90.21,34.49 90.07,34.62 90.07,35.7 90.21,35.84 90.5,35.84 90.63,35.97 90.63,36.16 90.5,36.29 90.21,36.29 90.07,36.43 90.07,36.62 90.21,36.75 90.5,36.75 90.63,36.88 90.63,37.07 90.5,37.21 90.21,37.21 90.07,37.34 90.07,38.79 92.97,41.69 92.97,44.67 93.64,45.34 93.64,56.55 92.7,57.49 92.7,60.47 93.23,61.01 93.23,65.45 92.42,66.26 92.42,71.18 91.86,71.74 91.86,77.84 90.85,78.85 90.85,84.07 89.53,85.39 89.53,86.1 89.27,86.36 88.73,86.36 87.72,85.35 v1(86.38,85.35)
  BOTTOM w0.147: U89.37 v1(86.38,85.35)
HSEC_MII1_RXD3: length 106.2
  L03_SIG1 w0.091: v1(97.64,6.59) 98.18,7.13 98.18,8.04 97.34,8.88 97.34,12.31 96.72,12.94 96.72,15.85 97.58,16.71 97.58,20.46 95.19,22.84 95.19,24.7 92.42,27.48 92.23,27.48 92.1,27.34 92.1,27.15 94.63,24.62 94.63,24.46 94.47,24.3 94.3,24.3 91.29,27.31 91.29,39.6 93.25,41.55 93.25,44.56 93.92,45.23 93.92,56.67 92.98,57.6 92.98,60.36 94.2,61.59 94.2,64.87 92.69,66.38 92.69,71.29 92.13,71.85 92.13,77.95 91.85,78.24 91.85,84.05 91.37,84.53 90.82,84.53 89.9,85.45 89.9,86.72 89.33,87.29 88.7,87.29 87.76,86.35 v1(86.38,86.35)
  BOTTOM w0.147: J15.146 98.44,5.79 v1(97.64,6.59) ; U89.35 v1(86.38,86.35)
HSEC_MII1_RXDV: length 106.1
  L03_SIG1 w0.091: v1(86.38,87.35) 86.84,87.81 89.33,87.81 90.26,86.87 90.26,86.27 90.67,85.86 92.54,85.86 92.88,85.52 92.88,83.14 92.41,82.67 92.41,74.19 93.01,73.59 93.01,66.49 94.48,65.02 94.48,61.48 93.26,60.25 93.26,57.72 94.19,56.78 94.19,45.12 93.52,44.45 93.52,41.44 91.6,39.52 91.6,28.97 91.69,28.88 91.88,28.88 92.41,29.42 92.6,29.42 92.73,29.28 92.73,29.09 92.2,28.56 92.2,28.37 93.63,26.94 93.82,26.94 94.35,27.48 94.54,27.48 94.67,27.34 94.67,27.15 94.14,26.62 94.14,26.43 94.27,26.3 94.46,26.3 95,26.83 95.19,26.83 95.32,26.7 95.32,26.51 94.79,25.97 94.79,25.78 95.61,24.95 95.61,22.92 98.56,19.97 98.56,17.13 97.05,15.62 97.05,14.04 98.17,12.91 98.17,9.22 98.5,8.88 98.5,6.65 97.91,6.06 97.37,6.06 96.5,5.19 96.5,5.03 v1(96.04,4.56)
  BOTTOM w0.147: v1(96.04,4.56) 96.34,4.56 96.84,4.06 J15.142 ; U89.33 v1(86.38,87.35)
HSEC_MII1_RXER: length 106
  TOP w0.147: v1(99.32,7.61) 98.22,8.71 96.27,8.71 95.03,7.47 95.03,4.23 95.24,4.02 J15.137
  L03_SIG1 w0.091: v1(99.32,7.61) 99.32,8.97 98.44,9.86 98.44,13.9 97.69,14.66 97.69,15.66 98.88,16.86 98.88,20.13 95.9,23.11 95.9,27.07 91.88,31.09 91.88,39.41 93.8,41.33 93.8,44.33 94.47,45.01 94.47,56.96 93.56,57.87 93.56,60.17 94.77,61.38 94.77,65.15 93.96,65.96 93.96,70.87 93.54,71.29 93.54,73.49 92.68,74.35 92.68,77.25 93.47,78.04 93.47,82.9 93.83,83.27 93.83,83.83 93.52,84.14 93.52,86.52 92.83,87.21 90.48,87.21 89.41,88.29 88.38,88.29 87.77,88.89 86.93,88.89 v1(86.38,88.35)
  BOTTOM w0.147: U89.31 v1(86.38,88.35)
HSEC_MII1_RXLINK: length 106.2
  L03_SIG1 w0.091: v1(86.38,90.85) 85.95,90.42 85.95,85.13 86.2,84.88 87.84,84.88 88.29,85.33 89.2,85.33 89.89,84.64 89.89,79.42 91.58,77.72 91.58,71.63 92.14,71.07 92.14,66.15 92.96,65.33 92.96,61.14 91.68,59.86 91.68,59.63 91.82,59.5 92.1,59.5 92.24,59.37 92.24,59.18 92.1,59.04 91.82,59.04 91.68,58.91 91.68,58.72 91.82,58.59 92.1,58.59 92.24,58.45 92.24,58.26 92.1,58.13 91.82,58.13 91.68,57.99 91.68,57.81 91.82,57.67 92.1,57.67 92.24,57.54 92.24,57.35 92.1,57.21 91.82,57.21 91.68,57.08 91.68,56.54 92.53,55.69 92.53,52.04 92.67,51.9 92.91,51.9 93.05,51.77 93.05,51.58 92.91,51.44 92.67,51.44 92.53,51.31 92.53,51.12 92.67,50.99 92.91,50.99 93.05,50.85 93.05,50.66 92.91,50.53 92.67,50.53 92.53,50.4 92.53,50.21 92.67,50.07 92.91,50.07 93.05,49.94 93.05,49.75 92.91,49.62 92.67,49.62 92.53,49.48 92.53,49.29 92.67,49.16 92.91,49.16 93.05,49.02 93.05,48.83 92.91,48.7 92.67,48.7 92.53,48.57 92.53,48.14 92.96,47.71 92.96,45.68 91.32,44.04 91.32,40.67 90.1,39.45 89.79,39.15 89.79,27.02 96.44,20.37 96.44,19.1 96.15,18.81 96.15,12.7 96.8,12.06 96.8,6.34 v1(96.04,5.58)
  BOTTOM w0.147: U89.26 v1(86.38,90.85) ; v1(96.04,5.58) 95.58,5.12 95.58,4.37 96.04,3.92 J15.140
HSEC_MII1_TXCLK: length 124.2
  TOP w0.147: J15.147 99.24,3.89 99.76,4.41 99.76,5.05 v1(99.24,5.58)
  L03_SIG1 w0.091: v1(99.24,5.58) 99.5,5.31 99.5,5.12 100.53,4.09 100.99,4.09 101.57,4.67 101.57,9.71 101.17,10.11 101.17,14.89 100.77,15.3 100.77,24.34 99.82,25.29 99.82,27.01 95.5,31.33 95.5,36.46 96.28,37.23 96.28,47.21 97.11,48.04 97.11,49.22 97.26,49.37 97.26,61.47 96.43,62.3 96.43,70.64 95.89,71.18 95.89,78.73 96.95,79.79 96.95,90.29 95.96,91.28 95.96,93.18 93.16,95.99 90.5,95.99 89.94,96.55 89.94,103.06 89.56,103.44 89.56,103.95 89.24,104.26 88,104.26 87.09,105.17 87.09,105.8 86.61,106.28 86.01,106.28 85.84,106.11 84.1,106.11 v1(83.09,107.12)
  BOTTOM w0.147: U88.18 v1(83.09,107.12)
HSEC_MII1_TXD0: length 124.1
  TOP w0.147: v1(100.84,5.58) 100.3,5.04 100.3,4.26 100.04,4 J15.149
  L03_SIG1 w0.091: v1(100.84,5.58) 100.37,6.04 100.37,9.1 99.27,10.2 99.27,14.84 99.82,15.39 99.82,23.62 97.98,25.46 97.98,27.62 97.69,27.91 97.5,27.91 97.11,27.52 96.92,27.52 96.79,27.65 96.79,27.84 97.18,28.23 97.18,28.42 97.05,28.55 96.86,28.55 96.46,28.16 96.27,28.16 96.14,28.3 96.14,28.49 96.53,28.88 96.53,29.07 96.4,29.2 96.21,29.2 95.82,28.81 95.63,28.81 95.49,28.94 95.49,29.13 95.89,29.52 95.89,29.71 95.75,29.85 95.56,29.85 95.17,29.46 94.98,29.46 94.85,29.59 94.85,29.78 95.24,30.17 95.24,30.36 95.11,30.49 94.92,30.49 94.52,30.1 94.34,30.1 94.2,30.24 94.2,30.43 94.59,30.82 94.59,31.01 94.46,31.14 94.27,31.14 93.88,30.75 93.69,30.75 93.55,30.88 93.55,31.07 93.95,31.46 93.95,31.65 93.57,32.03 93.57,32.57 93.7,32.71 94.1,32.71 94.23,32.84 94.23,33.03 94.1,33.17 93.7,33.17 93.57,33.3 93.57,33.49 93.7,33.62 94.1,33.62 94.23,33.76 94.23,33.95 94.1,34.08 93.7,34.08 93.57,34.21 93.57,34.4 93.7,34.54 94.1,34.54 94.23,34.67 94.23,34.86 94.1,34.99 93.7,34.99 93.57,35.13 93.57,38.28 95.45,40.16 95.45,49.49 96.36,50.39 96.36,59.99 95.59,60.76 95.59,65.49 94.78,66.3 94.78,71.21 94.36,71.63 94.36,82.54 95.16,83.34 95.16,84.9 94.51,85.55 94.51,88.01 93.16,89.36 93.16,94.4 92.39,95.16 89.53,95.16 87.59,97.1 87.59,100.97 87.82,101.2 87.82,101.76 86.75,102.84 v1(86.38,102.84)
  BOTTOM w0.147: U88.28 v1(86.38,102.84)
HSEC_MII1_TXD1: length 124.1
  L03_SIG1 w0.091: v1(100.84,7.61) 100.84,9.02 99.55,10.31 99.55,14.62 100.12,15.19 100.12,23.83 98.3,25.65 98.3,27.76 94.85,31.2 94.85,34.86 93.89,35.82 93.89,37.16 95.73,38.99 95.73,49.34 96.63,50.25 96.63,60.12 95.88,60.87 95.88,65.59 95.05,66.42 95.05,71.33 94.64,71.74 94.64,80.03 96.34,81.72 96.34,82.8 96.2,82.94 95.87,82.94 95.73,83.07 95.73,83.26 95.87,83.39 96.2,83.39 96.34,83.53 96.34,83.72 96.2,83.85 95.87,83.85 95.73,83.98 95.73,84.17 95.87,84.31 96.2,84.31 96.34,84.44 96.34,84.63 96.2,84.77 95.87,84.77 95.73,84.9 95.73,85.09 95.87,85.22 96.2,85.22 96.34,85.36 96.34,85.55 96.2,85.68 95.87,85.68 95.73,85.81 95.73,86 95.87,86.14 96.2,86.14 96.34,86.27 96.34,86.75 95.5,87.59 95.5,87.78 96.13,88.41 96.13,88.6 96,88.74 95.81,88.74 95.17,88.1 94.98,88.1 94.85,88.24 94.85,88.43 95.48,89.06 95.48,89.25 95.35,89.38 95.16,89.38 94.53,88.75 94.34,88.75 94.2,88.88 94.2,89.07 94.84,89.71 94.84,89.9 94.7,90.03 94.51,90.03 93.88,89.4 93.69,89.4 93.43,89.65 93.43,94.66 92.66,95.44 89.65,95.44 88.61,96.47 88.61,101.6 v1(86.38,103.84)
  BOTTOM w0.147: U88.26 v1(86.38,103.84) ; J15.150 100.04,4.07 100.28,4.32 100.28,7.05 v1(100.84,7.61)
HSEC_MII1_TXD2: length 124.3
  TOP w0.147: J15.151 100.84,3.88 101.43,4.47 101.43,6 v1(100.84,6.59)
  L03_SIG1 w0.091: v1(100.84,6.59) 101.3,7.06 101.3,9.25 100.78,9.77 100.78,14.84 100.44,15.18 100.44,23.9 98.75,25.58 98.75,27.69 95.19,31.25 95.19,35.02 94.42,35.8 94.42,36.42 95.12,37.12 95.12,37.55 96,38.43 96,49.17 96.91,50.08 96.91,60.26 96.15,61.01 96.15,65.7 95.33,66.53 95.33,73.3 95.61,73.59 95.61,78.84 96.68,79.9 96.68,89.25 95.57,90.35 95.57,93.04 95.31,93.3 94.84,93.3 94.62,93.09 94.62,91.09 94.37,90.83 93.95,90.83 93.71,91.08 93.71,94.9 92.89,95.71 90.38,95.71 89.67,96.43 89.67,96.7 89.53,96.84 89.23,96.84 89.1,96.97 89.1,97.16 89.23,97.29 89.53,97.29 89.67,97.43 89.67,97.62 89.53,97.75 89.23,97.75 89.1,97.88 89.1,98.07 89.23,98.21 89.53,98.21 89.67,98.34 89.67,98.53 89.53,98.66 89.23,98.66 89.1,98.8 89.1,98.99 89.23,99.12 89.53,99.12 89.67,99.26 89.67,99.44 89.53,99.58 89.23,99.58 89.1,99.71 89.1,99.9 89.23,100.04 89.53,100.04 89.67,100.17 89.67,102.84 89.19,103.31 87.9,103.31 v1(86.38,104.84)
  BOTTOM w0.147: U88.24 v1(86.38,104.84)
HSEC_MII1_TXD3: length 123.9
  L03_SIG1 w0.091: v1(86.38,105.84) 82.32,105.84 82.09,105.61 82.09,102.79 82.62,102.27 86.17,102.27 86.83,101.6 86.83,97.48 89.42,94.89 92.02,94.89 92.88,94.03 92.88,89.18 94.19,87.87 94.19,85.42 94.89,84.71 94.89,83.46 94.09,82.66 94.09,71.51 94.5,71.1 94.5,66.19 95.32,65.38 95.32,60.62 96.09,59.85 96.09,50.51 95.18,49.6 95.18,40.31 92.43,37.57 92.43,31.45 97.21,26.67 97.21,22.71 99.48,20.44 99.48,15.44 99,14.95 99,10.09 100.1,8.98 100.1,5.3 v1(100.84,4.56)
  BOTTOM w0.147: U88.22 v1(86.38,105.84) ; J15.152 v1(100.84,4.56)
HSEC_MII1_TXEN: length 124
  L03_SIG1 w0.091: v1(99.24,4.56) 99.98,3.82 101.49,3.82 101.85,4.18 101.85,9.82 101.44,10.23 101.44,15.12 101.04,15.52 101.04,26.18 95.83,31.39 95.83,34.14 96.55,34.86 96.55,47.09 98.22,48.76 98.22,49.24 97.65,49.8 97.65,61.6 96.7,62.55 96.7,79.15 97.7,80.15 97.7,89.93 97.04,90.59 97.04,95.17 95.06,97.15 90.94,97.15 90.21,97.88 90.21,103.17 89.85,103.53 89.85,104.1 89.4,104.56 88.14,104.56 87.49,105.21 87.49,105.84 86.76,106.57 85.91,106.57 85.73,106.38 84.3,106.38 84.09,106.59 v1(84.09,107.12)
  BOTTOM w0.147: J15.148 v1(99.24,4.56) ; U88.20 v1(84.09,107.12)
HSEC_MMC0_CLK: length 104.7
  TOP w0.147: v1(105.64,6.59) 106.21,6.02 106.21,4.36 105.64,3.79 J15.163
  L08_SIG2 w0.091: v1(51.14,52.98) 52.04,53.88 58.24,53.88 59.19,54.83 65.19,54.83 66.35,53.66 67.35,53.66 68.11,52.91 70.19,52.91 71.22,51.88 75.7,51.88 78.49,49.09 78.49,40.65 80.09,39.04 80.09,33.19 81.06,32.22 81.06,30.93 84.88,27.1 84.88,25.92 85.01,25.79 85.41,25.79 85.55,25.66 85.55,25.47 85.41,25.33 85.01,25.33 84.88,25.2 84.88,25.01 85.01,24.87 85.41,24.87 85.55,24.74 85.55,24.55 85.41,24.42 85.01,24.42 84.88,24.28 84.88,24.09 85.01,23.96 85.41,23.96 85.55,23.83 85.55,23.64 85.41,23.5 85.01,23.5 84.88,23.37 84.88,23.18 85.01,23.05 85.41,23.05 85.55,22.91 85.55,22.72 85.41,22.59 85.01,22.59 84.88,22.45 84.88,21.89 85.19,21.57 85.38,21.57 85.73,21.92 85.92,21.92 86.05,21.79 86.05,21.6 85.71,21.25 85.71,21.06 85.84,20.93 86.03,20.93 86.38,21.27 86.57,21.27 86.7,21.14 86.7,20.95 86.35,20.6 86.35,20.41 86.49,20.28 86.68,20.28 87.02,20.63 87.21,20.63 87.35,20.49 87.35,20.3 87,19.96 87,19.77 87.13,19.63 87.32,19.63 87.67,19.98 87.86,19.98 87.99,19.85 87.99,19.66 87.65,19.31 87.65,19.12 87.78,18.99 87.97,18.99 88.32,19.33 88.51,19.33 88.64,19.2 88.64,19.01 88.29,18.66 88.29,18.47 88.43,18.34 88.62,18.34 88.96,18.69 89.15,18.69 89.29,18.55 89.29,18.36 88.94,18.02 88.94,17.83 89.46,17.31 91.77,17.31 100.16,8.92 101.52,8.92 103.12,7.32 104.91,7.32 v1(105.64,6.59)
  BOTTOM w0.147: RA3.4 50.49,52.6 50.86,52.98 v1(51.14,52.98)
